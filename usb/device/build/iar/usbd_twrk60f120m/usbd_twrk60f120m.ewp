# IAR project usbd_twrk60f120m.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../../source/classes/include; ../../../source/classes/include; ../../../source/classes/include; ../../../../common/include; ../../../source/include/ehci; ../../../../host/source/host/ehci; ../../../source/classes/include; ../../../source/classes/include; ../../../source/classes/include; ../../../source/include; ../../../source/include/khci; ../../../../host/source/host/khci; ../../../source/classes/include; ../../../source/include/rtos; ../../../source/classes/include; ../../../../../mqx/source/io/adc/kadc; ../../../../../mqx/source/io/adc; ../../../../../mqx/source/io/cm; ../../../../../config/twrk60f120m; ../../../../../mqx/source/io/dma; ../../../../../mqx/source/io/enet/macnet; ../../../../../mqx/source/io/enet/phy; ../../../../../mqx/source/io/enet; ../../../../../mqx/source/io/esdhc; ../../../../../mqx/source/io/flashx/freescale; ../../../../../mqx/source/io/flashx; ../../../../../mqx/source/io/flashx/amd; ../../../../../mqx/source/io/flashx/fujitsu; ../../../../../mqx/source/io/flashx/spansion; ../../../../../mqx/source/io/flashx/atmel; ../../../../../mqx/source/io/flashx/istrata; ../../../../../mqx/source/io/flashx/sharp; ../../../../../mqx/source/io/can/flexcan; ../../../../../mqx/source/io/gpio/kgpio; ../../../../../mqx/source/io/gpio; ../../../../../mqx/source/io/hwtimer; ../../../../../mqx/source/io/i2c; ../../../../../mqx/source/io/i2c/polled; ../../../../../mqx/source/io/i2c/int; ../../../../../mqx/source/bsp/twrk60f120m; ../../../../../config/common; ../../../../../mqx/source/include; ../../../../../mqx/source/bsp/twrk60f120m; ../../../../../mqx/source/io/enet; ../../../../../mqx/source/io/debug; ../../../../../mqx/source/io/io_mem; ../../../../../mqx/source/io/io_null; ../../../../../mqx/source/io/pipe; ../../../../../mqx/source/io/lpm; ../../../../../mqx/source/io/lwadc; ../../../../../mqx/source/io/lwgpio; ../../../../../mqx/source/io/nandflash/nfc; ../../../../../mqx/source/io/nandflash; ../../../../../mqx/source/io/pcb; ../../../../../mqx/source/io/pcb/mqxa; ../../../../../mqx/source/io/pccard; ../../../../../mqx/source/io/pcflash; ../../../../../mqx/source/io/rtc; ../../../../../mqx/source/io/sai; ../../../../../mqx/source/io/sai/dma; ../../../../../mqx/source/io/sdcard/sdcard_esdhc; ../../../../../mqx/source/io/sdcard/sdcard_spi; ../../../../../mqx/source/io/sdcard; ../../../../../mqx/source/io/serial; ../../../../../mqx/source/io/spi; ../../../../../mqx/source/io/tchres; ../../../../../mqx/source/io/tfs; ../../../../../mqx/source/io/timer; ../../../../../mqx/source/io/usb; ../../../../../mqx/source/io/usb_dcd; ../../../../../mqx/source/io/usb_dcd/polled; ../../../../../mqx/source/io/usb_dcd/int; ../../../../../mqx/source/psp/cortex_m/compiler/iar; ../../../../../mqx/source/psp/cortex_m/cpu; ../../../../../mqx/source/psp/cortex_m; ../../../../../config/twrk60f120m; ../../../../../config/common; ../../../../../mqx/source/include; ../../../../../mqx/source/tad
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: ../../../../../mqx/source/io/debug; ../../../../../mqx/source/psp/cortex_m/compiler/iar; ../../../../../mqx/source/psp/cortex_m; ../../../../../mqx/source/psp/cortex_m/core/M4; ../../../../../config/twrk60f120m; ../../../../../mqx/source/include; ../../../../../config/common
  postbuild: "../../bat/usbd_twrk60f120m.bat" "../../../../.." "../../../../../lib/twrk60f120m.iar/debug/usb" iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG=1
  postbuild: "../../bat/usbd_twrk60f120m.bat" "../../../../.." "../../../../../lib/twrk60f120m.iar/release/usb" iar
  ILINK.IlinkOutputFile: libgeneric.out
  group USB Class Drivers/audio
    ../../../source/classes/audio/: usb_audio.c
    ../../../source/classes/include/: usb_audio.h
  group USB Class Drivers/cdc
    ../../../source/classes/cdc/: usb_cdc.c usb_cdc_pstn.c
    ../../../source/classes/include/: usb_cdc.h usb_cdc_pstn.h
  group USB Class Drivers/usb_class
    ../../../source/classes/common/: usb_class.c
    ../../../source/classes/include/: usb_class.h
  group USB Class Drivers/framework
    ../../../source/classes/common/: usb_framework.c
    ../../../source/classes/include/: usb_framework.h
  group USB Class Drivers/hid
    ../../../source/classes/hid/: usb_hid.c
    ../../../source/classes/include/: usb_hid.h
  group USB Class Drivers/msd
    ../../../source/classes/msd/: usb_msc.c usb_msc_scsi.c
    ../../../source/classes/include/: usb_msc.h usb_msc_scsi.h
  group USB Class Drivers/phdc
    ../../../source/classes/phdc/: usb_phdc.c
    ../../../source/classes/include/: usb_phdc.h
  group USB Device/include
    ../../../../common/include/: usb.h usb_debug.h usb_desc.h usb_error.h usb_misc.h usb_types.h usb_misc_prv.h usb_prv.h
    ../../../source/classes/include/: usb_stack_config.h
    ../../../source/include/: devapi.h dev_main.h dev_cnfg.h
  group USB Device/os
    ../../../source/include/rtos/: mqx_dev.h
  group USB Device/source
    ../../../source/device/: dev_cncl.c dev_ep_deinit.c dev_main.c dev_recv.c dev_send.c dev_shut.c dev_utl.c
  group USB Low Level Driver/ehci
    ../../../source/device/ehci/: callback_ehci.c ehci_dev_main.c
    ../../../source/include/ehci/: ehci_dev_main.h ehci_usbprv.h
    ../../../../host/source/host/ehci/: ehci_prv.h
  group USB Low Level Driver/khci
    ../../../source/device/khci/: callback_khci.c khci_dev_main.c
    ../../../source/include/khci/: khci_dev_main.h khci_usbprv.h
    ../../../../host/source/host/khci/: khci_prv.h
