<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>usbd_twrk53n512</project><configuration>debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>usbd_twrk53n512</project><configuration>release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\usbd_twrk53n512.ewp</path></project></workspace>
