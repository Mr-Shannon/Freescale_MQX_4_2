# Keil uVision project usbd_twrk60f120m.uvprojx, settings and files
target debug (ARM-ADS)
  device: MK60FN1M0xxx12 Freescale Semiconductor
  cpu: CPUTYPE("Cortex-M4.fp")
  output: usbd.lib (library)
  AfterMake: ../../bat/usbd_twrk60f120m.bat ../../../../.. ../../../../../lib/twrk60f120m.uv4/debug/usb uv4
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: -J../../../source/classes/include 
-J../../../source/classes/include 
-J../../../source/classes/include 
-J../../../../common/include 
-J../../../source/include/ehci 
-J../../../../host/source/host/ehci 
-J../../../source/classes/include 
-J../../../source/classes/include 
-J../../../source/classes/include 
-J../../../source/include 
-J../../../source/include/khci 
-J../../../../host/source/host/khci 
-J../../../source/classes/include 
-J../../../source/include/rtos 
-J../../../source/classes/include 
-J../../../../../mqx/source/io/adc/kadc 
-J../../../../../mqx/source/io/adc 
-J../../../../../mqx/source/io/cm 
-J../../../../../config/twrk60f120m 
-J../../../../../mqx/source/io/dma 
-J../../../../../mqx/source/io/enet/macnet 
-J../../../../../mqx/source/io/enet/phy 
-J../../../../../mqx/source/io/enet 
-J../../../../../mqx/source/io/esdhc 
-J../../../../../mqx/source/io/flashx/freescale 
-J../../../../../mqx/source/io/flashx 
-J../../../../../mqx/source/io/flashx/amd 
-J../../../../../mqx/source/io/flashx/fujitsu 
-J../../../../../mqx/source/io/flashx/spansion 
-J../../../../../mqx/source/io/flashx/atmel 
-J../../../../../mqx/source/io/flashx/istrata 
-J../../../../../mqx/source/io/flashx/sharp 
-J../../../../../mqx/source/io/can/flexcan 
-J../../../../../mqx/source/io/gpio/kgpio 
-J../../../../../mqx/source/io/gpio 
-J../../../../../mqx/source/io/hwtimer 
-J../../../../../mqx/source/io/i2c 
-J../../../../../mqx/source/io/i2c/polled 
-J../../../../../mqx/source/io/i2c/int 
-J../../../../../mqx/source/bsp/twrk60f120m 
-J../../../../../config/common 
-J../../../../../mqx/source/include 
-J../../../../../mqx/source/bsp/twrk60f120m 
-J../../../../../mqx/source/io/enet 
-J../../../../../mqx/source/io/debug 
-J../../../../../mqx/source/io/io_mem 
-J../../../../../mqx/source/io/io_null 
-J../../../../../mqx/source/io/pipe 
-J../../../../../mqx/source/io/lpm 
-J../../../../../mqx/source/io/lwadc 
-J../../../../../mqx/source/io/lwgpio 
-J../../../../../mqx/source/io/nandflash/nfc 
-J../../../../../mqx/source/io/nandflash 
-J../../../../../mqx/source/io/pcb 
-J../../../../../mqx/source/io/pcb/mqxa 
-J../../../../../mqx/source/io/pccard 
-J../../../../../mqx/source/io/pcflash 
-J../../../../../mqx/source/io/rtc 
-J../../../../../mqx/source/io/sai 
-J../../../../../mqx/source/io/sai/dma 
-J../../../../../mqx/source/io/sdcard/sdcard_esdhc 
-J../../../../../mqx/source/io/sdcard/sdcard_spi 
-J../../../../../mqx/source/io/sdcard 
-J../../../../../mqx/source/io/serial 
-J../../../../../mqx/source/io/spi 
-J../../../../../mqx/source/io/tchres 
-J../../../../../mqx/source/io/tfs 
-J../../../../../mqx/source/io/timer 
-J../../../../../mqx/source/io/usb 
-J../../../../../mqx/source/io/usb_dcd 
-J../../../../../mqx/source/io/usb_dcd/polled 
-J../../../../../mqx/source/io/usb_dcd/int 
-J../../../../../mqx/source/psp/cortex_m/compiler/rv_uv4 
-J../../../../../mqx/source/psp/cortex_m/cpu 
-J../../../../../mqx/source/psp/cortex_m 
-J../../../../../config/twrk60f120m 
-J../../../../../config/common 
-J../../../../../mqx/source/include 
-J../../../../../mqx/source/tad 
-J#J 
--library_interface=none 
--library_type=standardlib 
--c99 
--diag_suppress=1296,186
  c include: ../../../source/classes/include;../../../source/classes/include;../../../source/classes/include;../../../../common/include;../../../source/include/ehci;../../../../host/source/host/ehci;../../../source/classes/include;../../../source/classes/include;../../../source/classes/include;../../../source/include;../../../source/include/khci;../../../../host/source/host/khci;../../../source/classes/include;../../../source/include/rtos;../../../source/classes/include;../../../../../mqx/source/io/adc/kadc;../../../../../mqx/source/io/adc;../../../../../mqx/source/io/cm;../../../../../config/twrk60f120m;../../../../../mqx/source/io/dma;../../../../../mqx/source/io/enet/macnet;../../../../../mqx/source/io/enet/phy;../../../../../mqx/source/io/enet;../../../../../mqx/source/io/esdhc;../../../../../mqx/source/io/flashx/freescale;../../../../../mqx/source/io/flashx;../../../../../mqx/source/io/flashx/amd;../../../../../mqx/source/io/flashx/fujitsu;../../../../../mqx/source/io/flashx/spansion;../../../../../mqx/source/io/flashx/atmel;../../../../../mqx/source/io/flashx/istrata;../../../../../mqx/source/io/flashx/sharp;../../../../../mqx/source/io/can/flexcan;../../../../../mqx/source/io/gpio/kgpio;../../../../../mqx/source/io/gpio;../../../../../mqx/source/io/hwtimer;../../../../../mqx/source/io/i2c;../../../../../mqx/source/io/i2c/polled;../../../../../mqx/source/io/i2c/int;../../../../../mqx/source/bsp/twrk60f120m;../../../../../config/common;../../../../../mqx/source/include;../../../../../mqx/source/bsp/twrk60f120m;../../../../../mqx/source/io/enet;../../../../../mqx/source/io/debug;../../../../../mqx/source/io/io_mem;../../../../../mqx/source/io/io_null;../../../../../mqx/source/io/pipe;../../../../../mqx/source/io/lpm;../../../../../mqx/source/io/lwadc;../../../../../mqx/source/io/lwgpio;../../../../../mqx/source/io/nandflash/nfc;../../../../../mqx/source/io/nandflash;../../../../../mqx/source/io/pcb;../../../../../mqx/source/io/pcb/mqxa;../../../../../mqx/source/io/pccard;../../../../../mqx/source/io/pcflash;../../../../../mqx/source/io/rtc;../../../../../mqx/source/io/sai;../../../../../mqx/source/io/sai/dma;../../../../../mqx/source/io/sdcard/sdcard_esdhc;../../../../../mqx/source/io/sdcard/sdcard_spi;../../../../../mqx/source/io/sdcard;../../../../../mqx/source/io/serial;../../../../../mqx/source/io/spi;../../../../../mqx/source/io/tchres;../../../../../mqx/source/io/tfs;../../../../../mqx/source/io/timer;../../../../../mqx/source/io/usb;../../../../../mqx/source/io/usb_dcd;../../../../../mqx/source/io/usb_dcd/polled;../../../../../mqx/source/io/usb_dcd/int;../../../../../mqx/source/psp/cortex_m/compiler/rv_uv4;../../../../../mqx/source/psp/cortex_m/cpu;../../../../../mqx/source/psp/cortex_m;../../../../../config/twrk60f120m;../../../../../config/common;../../../../../mqx/source/include;../../../../../mqx/source/tad
  asm misc: --cpreproc_opts '-D_DEBUG=1' --cpreproc
  asm include: ../../../../../mqx/source/io/debug;../../../../../mqx/source/psp/cortex_m/compiler/rv_uv4;../../../../../mqx/source/psp/cortex_m;../../../../../mqx/source/psp/cortex_m/core/M4;../../../../../config/twrk60f120m;../../../../../mqx/source/include;../../../../../config/common
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk60f120m.uv4\mqx\intflash.scf
  group USB Class Drivers/audio
    ../../../source/classes/audio/: usb_audio.c
    ../../../source/classes/include/: usb_audio.h
  group USB Class Drivers/cdc
    ../../../source/classes/cdc/: usb_cdc.c usb_cdc_pstn.c
    ../../../source/classes/include/: usb_cdc.h usb_cdc_pstn.h
  group USB Class Drivers/usb_class
    ../../../source/classes/common/: usb_class.c
    ../../../source/classes/include/: usb_class.h
  group USB Device/include
    ../../../../common/include/: usb.h usb_debug.h usb_desc.h usb_error.h usb_misc.h usb_types.h usb_misc_prv.h usb_prv.h
    ../../../source/classes/include/: usb_stack_config.h
    ../../../source/include/: devapi.h dev_main.h dev_cnfg.h
  group USB Low Level Driver/ehci
    ../../../source/device/ehci/: callback_ehci.c ehci_dev_main.c
    ../../../source/include/ehci/: ehci_dev_main.h ehci_usbprv.h
    ../../../../host/source/host/ehci/: ehci_prv.h
  group USB Class Drivers/framework
    ../../../source/classes/common/: usb_framework.c
    ../../../source/classes/include/: usb_framework.h
  group USB Class Drivers/hid
    ../../../source/classes/hid/: usb_hid.c
    ../../../source/classes/include/: usb_hid.h
  group USB Low Level Driver/khci
    ../../../source/device/khci/: callback_khci.c khci_dev_main.c
    ../../../source/include/khci/: khci_dev_main.h khci_usbprv.h
    ../../../../host/source/host/khci/: khci_prv.h
  group USB Class Drivers/msd
    ../../../source/classes/msd/: usb_msc.c usb_msc_scsi.c
    ../../../source/classes/include/: usb_msc.h usb_msc_scsi.h
  group USB Device/os
    ../../../source/include/rtos/: mqx_dev.h
  group USB Class Drivers/phdc
    ../../../source/classes/phdc/: usb_phdc.c
    ../../../source/classes/include/: usb_phdc.h
  group USB Device/source
    ../../../source/device/: dev_cncl.c dev_ep_deinit.c dev_main.c dev_recv.c dev_send.c dev_shut.c dev_utl.c
target release (ARM-ADS)
  device: MK60FN1M0xxx12 Freescale Semiconductor
  cpu: CPUTYPE("Cortex-M4.fp")
  output: usbd.lib (library)
  AfterMake: ../../bat/usbd_twrk60f120m.bat ../../../../.. ../../../../../lib/twrk60f120m.uv4/release/usb uv4
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG=1
  c misc: as above
  c include: as above
  asm misc: --cpreproc_opts '-DNDEBUG=1' --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk60f120m.uv4\mqx\intflash.scf
