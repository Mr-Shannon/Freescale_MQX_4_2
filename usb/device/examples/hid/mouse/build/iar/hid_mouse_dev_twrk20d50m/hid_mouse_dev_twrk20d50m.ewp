# IAR project hid_mouse_dev_twrk20d50m.ewp, settings and files
configuration int flash debug (ARM, debug)
  General.OGChipSelectEditMenu: MK20DX128xxx5 Freescale MK20DX128xxx5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../lib/twrk20d50m.iar/debug/bsp/Generated_Code; ../../../../../../../../lib/twrk20d50m.iar/debug; ../../../../../../../../lib/twrk20d50m.iar/debug/bsp; ../../../../../../../../lib/twrk20d50m.iar/debug/psp; ../../../../../../../../lib/twrk20d50m.iar/debug/usb
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: ../../../../../../../../lib/twrk20d50m.iar/debug/bsp/Generated_Code; ../../../../../../../../lib/twrk20d50m.iar/debug; ../../../../../../../../lib/twrk20d50m.iar/debug/bsp; ../../../../../../../../lib/twrk20d50m.iar/debug/psp; ../../../../../../../../lib/twrk20d50m.iar/debug/usb
  ILINK.IlinkOutputFile: hid_mouse_dev.out
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrk20d50m.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/twrk20d50m.iar/debug/bsp/bsp.a; ../../../../../../../../lib/twrk20d50m.iar/debug/psp/psp.a; ../../../../../../../../lib/twrk20d50m.iar/debug/usb/usbd.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration int flash release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../lib/twrk20d50m.iar/release/bsp/Generated_Code; ../../../../../../../../lib/twrk20d50m.iar/release; ../../../../../../../../lib/twrk20d50m.iar/release/bsp; ../../../../../../../../lib/twrk20d50m.iar/release/psp; ../../../../../../../../lib/twrk20d50m.iar/release/usb
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG=1
  AARM.AUserIncludes: ../../../../../../../../lib/twrk20d50m.iar/release/bsp/Generated_Code; ../../../../../../../../lib/twrk20d50m.iar/release; ../../../../../../../../lib/twrk20d50m.iar/release/bsp; ../../../../../../../../lib/twrk20d50m.iar/release/psp; ../../../../../../../../lib/twrk20d50m.iar/release/usb
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrk20d50m.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/twrk20d50m.iar/release/bsp/bsp.a; ../../../../../../../../lib/twrk20d50m.iar/release/psp/psp.a; ../../../../../../../../lib/twrk20d50m.iar/release/usb/usbd.a
  group Sources
    ../../../: mouse.c mouse.h usb_descriptor.c usb_descriptor.h
