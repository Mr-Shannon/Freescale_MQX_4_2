<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>bsp_twrk40x256</project><configuration>debug</configuration></member><member><project>psp_twrk40x256</project><configuration>debug</configuration></member><member><project>usbd_twrk40x256</project><configuration>debug</configuration></member><member><project>msd_disk_twrk40x256</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>bsp_twrk40x256</project><configuration>release</configuration></member><member><project>psp_twrk40x256</project><configuration>release</configuration></member><member><project>usbd_twrk40x256</project><configuration>release</configuration></member><member><project>msd_disk_twrk40x256</project><configuration>int flash release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\mqx\build\iar\bsp_twrk40x256\bsp_twrk40x256.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\mqx\build\iar\psp_twrk40x256\psp_twrk40x256.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\build\iar\usbd_twrk40x256\usbd_twrk40x256.ewp</path></project><project><path>$WS_DIR$\msd_disk_twrk40x256.ewp</path></project></workspace>
