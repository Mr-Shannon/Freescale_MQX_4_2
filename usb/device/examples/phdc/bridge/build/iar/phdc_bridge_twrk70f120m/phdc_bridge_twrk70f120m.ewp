# IAR project phdc_bridge_twrk70f120m.ewp, settings and files
configuration int flash sramdata debug (ARM, debug)
  General.OGChipSelectEditMenu: MK70FN1M0xxx12 Freescale MK70FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../lib/twrk70f120m.iar/debug/bsp/Generated_Code; ../../../../../../../../lib/twrk70f120m.iar/debug; ../../../../../../../../lib/twrk70f120m.iar/debug/bsp; ../../../../../../../../lib/twrk70f120m.iar/debug/psp; ../../../../../../../../lib/twrk70f120m.iar/debug/rtcs; ../../../../../../../../lib/twrk70f120m.iar/debug/usb
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: ../../../../../../../../lib/twrk70f120m.iar/debug/bsp/Generated_Code; ../../../../../../../../lib/twrk70f120m.iar/debug; ../../../../../../../../lib/twrk70f120m.iar/debug/bsp; ../../../../../../../../lib/twrk70f120m.iar/debug/psp; ../../../../../../../../lib/twrk70f120m.iar/debug/rtcs; ../../../../../../../../lib/twrk70f120m.iar/debug/usb
  OBJCOPY.OOCOutputFile: twrk70f120m.srec
  ILINK.IlinkOutputFile: phdc_bridge.out
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrk70f120m.iar/debug/bsp/intflash_sramdata.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/twrk70f120m.iar/debug/bsp/bsp.a; ../../../../../../../../lib/twrk70f120m.iar/debug/psp/psp.a; ../../../../../../../../lib/twrk70f120m.iar/debug/rtcs/rtcs.a; ../../../../../../../../lib/twrk70f120m.iar/debug/usb/usbd.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration int flash sramdata release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../lib/twrk70f120m.iar/release/bsp/Generated_Code; ../../../../../../../../lib/twrk70f120m.iar/release; ../../../../../../../../lib/twrk70f120m.iar/release/bsp; ../../../../../../../../lib/twrk70f120m.iar/release/psp; ../../../../../../../../lib/twrk70f120m.iar/release/rtcs; ../../../../../../../../lib/twrk70f120m.iar/release/usb
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG=1
  AARM.AUserIncludes: ../../../../../../../../lib/twrk70f120m.iar/release/bsp/Generated_Code; ../../../../../../../../lib/twrk70f120m.iar/release; ../../../../../../../../lib/twrk70f120m.iar/release/bsp; ../../../../../../../../lib/twrk70f120m.iar/release/psp; ../../../../../../../../lib/twrk70f120m.iar/release/rtcs; ../../../../../../../../lib/twrk70f120m.iar/release/usb
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrk70f120m.iar/release/bsp/intflash_sramdata.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/twrk70f120m.iar/release/bsp/bsp.a; ../../../../../../../../lib/twrk70f120m.iar/release/psp/psp.a; ../../../../../../../../lib/twrk70f120m.iar/release/rtcs/rtcs.a; ../../../../../../../../lib/twrk70f120m.iar/release/usb/usbd.a
configuration int flash ddrdata debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrk70f120m.iar/debug/bsp/intflash_ddrdata.icf
configuration int flash ddrdata release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG=1
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrk70f120m.iar/release/bsp/intflash_ddrdata.icf
  ILINK.IlinkAdditionalLibs: as above
  group Sources
    ../../../: bridge.c bridge.h ieee11073_nom_codes.h ieee11073_phd_types.h phdc_server.c phdc_server.h usb_descriptor.c usb_descriptor.h
