# Keil uVision project phdc_bridge_twrk70f120m.uvprojx, settings and files
target int flash sramdata debug (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: CPUTYPE("Cortex-M4.fp")
  output: phdc_bridge.axf +hex
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: -J../../.. 
-J../../../../../../../../lib/twrk70f120m.uv4/debug/bsp/Generated_Code 
-J../../../../../../../../lib/twrk70f120m.uv4/debug 
-J../../../../../../../../lib/twrk70f120m.uv4/debug/bsp 
-J../../../../../../../../lib/twrk70f120m.uv4/debug/psp 
-J../../../../../../../../lib/twrk70f120m.uv4/debug/rtcs 
-J../../../../../../../../lib/twrk70f120m.uv4/debug/usb 
-J#J 
--library_interface=none 
--library_type=standardlib 
--c99 
--diag_suppress=1296,186
  c include: ../../..;../../../../../../../../lib/twrk70f120m.uv4/debug/bsp/Generated_Code;../../../../../../../../lib/twrk70f120m.uv4/debug;../../../../../../../../lib/twrk70f120m.uv4/debug/bsp;../../../../../../../../lib/twrk70f120m.uv4/debug/psp;../../../../../../../../lib/twrk70f120m.uv4/debug/rtcs;../../../../../../../../lib/twrk70f120m.uv4/debug/usb
  asm misc: --cpreproc_opts '-D_DEBUG=1' --cpreproc
  asm include: ../../../../../../../../lib/twrk70f120m.uv4/debug/bsp/Generated_Code;../../../../../../../../lib/twrk70f120m.uv4/debug;../../../../../../../../lib/twrk70f120m.uv4/debug/bsp;../../../../../../../../lib/twrk70f120m.uv4/debug/psp;../../../../../../../../lib/twrk70f120m.uv4/debug/rtcs;../../../../../../../../lib/twrk70f120m.uv4/debug/usb
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../../../../../lib/twrk70f120m.uv4/debug/bsp/intflash_sramdata.scf
  link misc: ../../../../../../../../lib/twrk70f120m.uv4/debug/bsp/bsp.lib 
../../../../../../../../lib/twrk70f120m.uv4/debug/psp/psp.lib 
../../../../../../../../lib/twrk70f120m.uv4/debug/rtcs/rtcs.lib 
../../../../../../../../lib/twrk70f120m.uv4/debug/usb/usbd.lib 
../../../../../../../../lib/twrk70f120m.uv4/debug/bsp/bsp.lib(vectors.o) 
../../../../../../../../lib/twrk70f120m.uv4/debug/psp/psp.lib(linker_symbols.o) 
--keep linker_symbols.o(KERNEL_DATA_START) 
--keep linker_symbols.o(KERNEL_DATA_END) 
--keep linker_symbols.o(BOOT_STACK) 
--keep vectors.o(.vectors_rom) 
--remove 
--autoat 
--entry 
__boot
  group Sources
    ../../../: bridge.c bridge.h ieee11073_nom_codes.h ieee11073_phd_types.h phdc_server.c phdc_server.h usb_descriptor.c usb_descriptor.h
target int flash sramdata release (ARM-ADS)
  device: MK70FX512xxx12 Freescale Semiconductor
  cpu: CPUTYPE("Cortex-M4.fp")
  output: phdc_bridge.axf +hex
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG=1
  c misc: -J../../.. 
-J../../../../../../../../lib/twrk70f120m.uv4/release/bsp/Generated_Code 
-J../../../../../../../../lib/twrk70f120m.uv4/release 
-J../../../../../../../../lib/twrk70f120m.uv4/release/bsp 
-J../../../../../../../../lib/twrk70f120m.uv4/release/psp 
-J../../../../../../../../lib/twrk70f120m.uv4/release/rtcs 
-J../../../../../../../../lib/twrk70f120m.uv4/release/usb 
-J#J 
--library_interface=none 
--library_type=standardlib 
--c99 
--diag_suppress=1296,186
  c include: ../../..;../../../../../../../../lib/twrk70f120m.uv4/release/bsp/Generated_Code;../../../../../../../../lib/twrk70f120m.uv4/release;../../../../../../../../lib/twrk70f120m.uv4/release/bsp;../../../../../../../../lib/twrk70f120m.uv4/release/psp;../../../../../../../../lib/twrk70f120m.uv4/release/rtcs;../../../../../../../../lib/twrk70f120m.uv4/release/usb
  asm misc: --cpreproc_opts '-DNDEBUG=1' --cpreproc
  asm include: ../../../../../../../../lib/twrk70f120m.uv4/release/bsp/Generated_Code;../../../../../../../../lib/twrk70f120m.uv4/release;../../../../../../../../lib/twrk70f120m.uv4/release/bsp;../../../../../../../../lib/twrk70f120m.uv4/release/psp;../../../../../../../../lib/twrk70f120m.uv4/release/rtcs;../../../../../../../../lib/twrk70f120m.uv4/release/usb
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../../../../../lib/twrk70f120m.uv4/release/bsp/intflash_sramdata.scf
  link misc: ../../../../../../../../lib/twrk70f120m.uv4/release/bsp/bsp.lib 
../../../../../../../../lib/twrk70f120m.uv4/release/psp/psp.lib 
../../../../../../../../lib/twrk70f120m.uv4/release/rtcs/rtcs.lib 
../../../../../../../../lib/twrk70f120m.uv4/release/usb/usbd.lib 
../../../../../../../../lib/twrk70f120m.uv4/release/bsp/bsp.lib(vectors.o) 
../../../../../../../../lib/twrk70f120m.uv4/release/psp/psp.lib(linker_symbols.o) 
--keep linker_symbols.o(KERNEL_DATA_START) 
--keep linker_symbols.o(KERNEL_DATA_END) 
--keep linker_symbols.o(BOOT_STACK) 
--keep vectors.o(.vectors_rom) 
--remove 
--autoat 
--entry 
__boot
target int flash ddrdata debug (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: CPUTYPE("Cortex-M4.fp")
  output: phdc_bridge.axf +hex
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: as above
  c include: as above
  asm misc: --cpreproc_opts '-D_DEBUG=1' --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x70000000 size 0x7fffff0
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../../../../../lib/twrk70f120m.uv4/debug/bsp/intflash_ddrdata.scf
  link misc: as above
target int flash ddrdata release (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: CPUTYPE("Cortex-M4.fp")
  output: phdc_bridge.axf +hex
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG=1
  c misc: as above
  c include: as above
  asm misc: --cpreproc_opts '-DNDEBUG=1' --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x70000000 size 0x7fffff0
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../../../../../lib/twrk70f120m.uv4/release/bsp/intflash_ddrdata.scf
  link misc: as above
