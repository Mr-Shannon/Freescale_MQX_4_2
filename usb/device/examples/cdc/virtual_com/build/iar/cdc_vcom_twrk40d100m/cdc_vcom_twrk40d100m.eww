<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>bsp_twrk40d100m</project><configuration>debug</configuration></member><member><project>psp_twrk40d100m</project><configuration>debug</configuration></member><member><project>usbd_twrk40d100m</project><configuration>debug</configuration></member><member><project>cdc_vcom_twrk40d100m</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>bsp_twrk40d100m</project><configuration>release</configuration></member><member><project>psp_twrk40d100m</project><configuration>release</configuration></member><member><project>usbd_twrk40d100m</project><configuration>release</configuration></member><member><project>cdc_vcom_twrk40d100m</project><configuration>int flash release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\mqx\build\iar\bsp_twrk40d100m\bsp_twrk40d100m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\mqx\build\iar\psp_twrk40d100m\psp_twrk40d100m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\build\iar\usbd_twrk40d100m\usbd_twrk40d100m.ewp</path></project><project><path>$WS_DIR$\cdc_vcom_twrk40d100m.ewp</path></project></workspace>
