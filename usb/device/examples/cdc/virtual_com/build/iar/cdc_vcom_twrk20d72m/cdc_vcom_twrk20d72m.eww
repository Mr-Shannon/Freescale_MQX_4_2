<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>bsp_twrk20d72m</project><configuration>debug</configuration></member><member><project>psp_twrk20d72m</project><configuration>debug</configuration></member><member><project>usbd_twrk20d72m</project><configuration>debug</configuration></member><member><project>cdc_vcom_twrk20d72m</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>bsp_twrk20d72m</project><configuration>release</configuration></member><member><project>psp_twrk20d72m</project><configuration>release</configuration></member><member><project>usbd_twrk20d72m</project><configuration>release</configuration></member><member><project>cdc_vcom_twrk20d72m</project><configuration>int flash release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\mqx\build\iar\bsp_twrk20d72m\bsp_twrk20d72m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\mqx\build\iar\psp_twrk20d72m\psp_twrk20d72m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\build\iar\usbd_twrk20d72m\usbd_twrk20d72m.ewp</path></project><project><path>$WS_DIR$\cdc_vcom_twrk20d72m.ewp</path></project></workspace>
