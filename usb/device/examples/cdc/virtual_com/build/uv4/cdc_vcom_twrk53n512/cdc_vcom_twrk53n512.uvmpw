<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <WorkspaceName>WorkSpace</WorkspaceName>
<project><PathAndName>..\..\..\..\..\..\..\..\mqx\build\uv4\bsp_twrk53n512\bsp_twrk53n512.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\..\..\..\mqx\build\uv4\psp_twrk53n512\psp_twrk53n512.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\..\build\uv4\usbd_twrk53n512\usbd_twrk53n512.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>cdc_vcom_twrk53n512.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project></ProjectWorkspace>
