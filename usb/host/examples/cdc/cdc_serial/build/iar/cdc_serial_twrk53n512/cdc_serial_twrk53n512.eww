<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>bsp_twrk53n512</project><configuration>debug</configuration></member><member><project>psp_twrk53n512</project><configuration>debug</configuration></member><member><project>usbh_twrk53n512</project><configuration>debug</configuration></member><member><project>cdc_serial_twrk53n512</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>bsp_twrk53n512</project><configuration>release</configuration></member><member><project>psp_twrk53n512</project><configuration>release</configuration></member><member><project>usbh_twrk53n512</project><configuration>release</configuration></member><member><project>cdc_serial_twrk53n512</project><configuration>int flash release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\mqx\build\iar\bsp_twrk53n512\bsp_twrk53n512.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\mqx\build\iar\psp_twrk53n512\psp_twrk53n512.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\build\iar\usbh_twrk53n512\usbh_twrk53n512.ewp</path></project><project><path>$WS_DIR$\cdc_serial_twrk53n512.ewp</path></project></workspace>
