<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>bsp_twrk20d72m</project><configuration>debug</configuration></member><member><project>psp_twrk20d72m</project><configuration>debug</configuration></member><member><project>mfs_twrk20d72m</project><configuration>debug</configuration></member><member><project>shell_twrk20d72m</project><configuration>debug</configuration></member><member><project>usbh_twrk20d72m</project><configuration>debug</configuration></member><member><project>audio_microphone_twrk20d72m</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>bsp_twrk20d72m</project><configuration>release</configuration></member><member><project>psp_twrk20d72m</project><configuration>release</configuration></member><member><project>mfs_twrk20d72m</project><configuration>release</configuration></member><member><project>shell_twrk20d72m</project><configuration>release</configuration></member><member><project>usbh_twrk20d72m</project><configuration>release</configuration></member><member><project>audio_microphone_twrk20d72m</project><configuration>int flash release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\mqx\build\iar\bsp_twrk20d72m\bsp_twrk20d72m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\mqx\build\iar\psp_twrk20d72m\psp_twrk20d72m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\mfs\build\iar\mfs_twrk20d72m\mfs_twrk20d72m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\shell\build\iar\shell_twrk20d72m\shell_twrk20d72m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\build\iar\usbh_twrk20d72m\usbh_twrk20d72m.ewp</path></project><project><path>$WS_DIR$\audio_microphone_twrk20d72m.ewp</path></project></workspace>
