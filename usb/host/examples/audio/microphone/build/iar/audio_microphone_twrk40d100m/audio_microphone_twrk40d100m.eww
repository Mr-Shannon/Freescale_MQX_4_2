<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>bsp_twrk40d100m</project><configuration>debug</configuration></member><member><project>psp_twrk40d100m</project><configuration>debug</configuration></member><member><project>mfs_twrk40d100m</project><configuration>debug</configuration></member><member><project>shell_twrk40d100m</project><configuration>debug</configuration></member><member><project>usbh_twrk40d100m</project><configuration>debug</configuration></member><member><project>audio_microphone_twrk40d100m</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>bsp_twrk40d100m</project><configuration>release</configuration></member><member><project>psp_twrk40d100m</project><configuration>release</configuration></member><member><project>mfs_twrk40d100m</project><configuration>release</configuration></member><member><project>shell_twrk40d100m</project><configuration>release</configuration></member><member><project>usbh_twrk40d100m</project><configuration>release</configuration></member><member><project>audio_microphone_twrk40d100m</project><configuration>int flash release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\mqx\build\iar\bsp_twrk40d100m\bsp_twrk40d100m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\mqx\build\iar\psp_twrk40d100m\psp_twrk40d100m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\mfs\build\iar\mfs_twrk40d100m\mfs_twrk40d100m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\shell\build\iar\shell_twrk40d100m\shell_twrk40d100m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\build\iar\usbh_twrk40d100m\usbh_twrk40d100m.ewp</path></project><project><path>$WS_DIR$\audio_microphone_twrk40d100m.ewp</path></project></workspace>
