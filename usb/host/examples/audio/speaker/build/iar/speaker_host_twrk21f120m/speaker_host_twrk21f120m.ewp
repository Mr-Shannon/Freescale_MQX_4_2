# IAR project speaker_host_twrk21f120m.ewp, settings and files
configuration int flash debug (ARM, debug)
  General.OGChipSelectEditMenu: MK21FN1M0xxx12 Freescale MK21FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../lib/twrk21f120m.iar/debug/bsp/Generated_Code; ../../../../../../../../lib/twrk21f120m.iar/debug; ../../../../../../../../lib/twrk21f120m.iar/debug/bsp; ../../../../../../../../lib/twrk21f120m.iar/debug/psp; ../../../../../../../../lib/twrk21f120m.iar/debug/mfs; ../../../../../../../../lib/twrk21f120m.iar/debug/shell; ../../../../../../../../lib/twrk21f120m.iar/debug/usb
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: ../../../../../../../../lib/twrk21f120m.iar/debug/bsp/Generated_Code; ../../../../../../../../lib/twrk21f120m.iar/debug; ../../../../../../../../lib/twrk21f120m.iar/debug/bsp; ../../../../../../../../lib/twrk21f120m.iar/debug/psp; ../../../../../../../../lib/twrk21f120m.iar/debug/mfs; ../../../../../../../../lib/twrk21f120m.iar/debug/shell; ../../../../../../../../lib/twrk21f120m.iar/debug/usb
  OBJCOPY.OOCOutputFile: twrk21f120m.srec
  ILINK.IlinkOutputFile: speaker_host.out
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrk21f120m.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/twrk21f120m.iar/debug/bsp/bsp.a; ../../../../../../../../lib/twrk21f120m.iar/debug/psp/psp.a; ../../../../../../../../lib/twrk21f120m.iar/debug/mfs/mfs.a; ../../../../../../../../lib/twrk21f120m.iar/debug/shell/shell.a; ../../../../../../../../lib/twrk21f120m.iar/debug/usb/usbh.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration int flash release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../lib/twrk21f120m.iar/release/bsp/Generated_Code; ../../../../../../../../lib/twrk21f120m.iar/release; ../../../../../../../../lib/twrk21f120m.iar/release/bsp; ../../../../../../../../lib/twrk21f120m.iar/release/psp; ../../../../../../../../lib/twrk21f120m.iar/release/mfs; ../../../../../../../../lib/twrk21f120m.iar/release/shell; ../../../../../../../../lib/twrk21f120m.iar/release/usb
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG=1
  AARM.AUserIncludes: ../../../../../../../../lib/twrk21f120m.iar/release/bsp/Generated_Code; ../../../../../../../../lib/twrk21f120m.iar/release; ../../../../../../../../lib/twrk21f120m.iar/release/bsp; ../../../../../../../../lib/twrk21f120m.iar/release/psp; ../../../../../../../../lib/twrk21f120m.iar/release/mfs; ../../../../../../../../lib/twrk21f120m.iar/release/shell; ../../../../../../../../lib/twrk21f120m.iar/release/usb
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrk21f120m.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/twrk21f120m.iar/release/bsp/bsp.a; ../../../../../../../../lib/twrk21f120m.iar/release/psp/psp.a; ../../../../../../../../lib/twrk21f120m.iar/release/mfs/mfs.a; ../../../../../../../../lib/twrk21f120m.iar/release/shell/shell.a; ../../../../../../../../lib/twrk21f120m.iar/release/usb/usbh.a
  group Sources
    ../../../: audio_speaker.c audio_speaker.h sh_audio.c sh_audio.h sd_card.h sd_card.c hidkeyboard.h hidkeyboard.c main.c usb_classes.c usb_classes.h wav.c wav.h
