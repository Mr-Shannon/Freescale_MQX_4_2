# IAR project speaker_host_twrk60n512.ewp, settings and files
configuration int flash debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../lib/twrk60n512.iar/debug/bsp/Generated_Code; ../../../../../../../../lib/twrk60n512.iar/debug; ../../../../../../../../lib/twrk60n512.iar/debug/bsp; ../../../../../../../../lib/twrk60n512.iar/debug/psp; ../../../../../../../../lib/twrk60n512.iar/debug/mfs; ../../../../../../../../lib/twrk60n512.iar/debug/shell; ../../../../../../../../lib/twrk60n512.iar/debug/usb
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: ../../../../../../../../lib/twrk60n512.iar/debug/bsp/Generated_Code; ../../../../../../../../lib/twrk60n512.iar/debug; ../../../../../../../../lib/twrk60n512.iar/debug/bsp; ../../../../../../../../lib/twrk60n512.iar/debug/psp; ../../../../../../../../lib/twrk60n512.iar/debug/mfs; ../../../../../../../../lib/twrk60n512.iar/debug/shell; ../../../../../../../../lib/twrk60n512.iar/debug/usb
  ILINK.IlinkOutputFile: speaker_host.out
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrk60n512.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/twrk60n512.iar/debug/bsp/bsp.a; ../../../../../../../../lib/twrk60n512.iar/debug/psp/psp.a; ../../../../../../../../lib/twrk60n512.iar/debug/mfs/mfs.a; ../../../../../../../../lib/twrk60n512.iar/debug/shell/shell.a; ../../../../../../../../lib/twrk60n512.iar/debug/usb/usbh.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration int flash release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../lib/twrk60n512.iar/release/bsp/Generated_Code; ../../../../../../../../lib/twrk60n512.iar/release; ../../../../../../../../lib/twrk60n512.iar/release/bsp; ../../../../../../../../lib/twrk60n512.iar/release/psp; ../../../../../../../../lib/twrk60n512.iar/release/mfs; ../../../../../../../../lib/twrk60n512.iar/release/shell; ../../../../../../../../lib/twrk60n512.iar/release/usb
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG=1
  AARM.AUserIncludes: ../../../../../../../../lib/twrk60n512.iar/release/bsp/Generated_Code; ../../../../../../../../lib/twrk60n512.iar/release; ../../../../../../../../lib/twrk60n512.iar/release/bsp; ../../../../../../../../lib/twrk60n512.iar/release/psp; ../../../../../../../../lib/twrk60n512.iar/release/mfs; ../../../../../../../../lib/twrk60n512.iar/release/shell; ../../../../../../../../lib/twrk60n512.iar/release/usb
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrk60n512.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/twrk60n512.iar/release/bsp/bsp.a; ../../../../../../../../lib/twrk60n512.iar/release/psp/psp.a; ../../../../../../../../lib/twrk60n512.iar/release/mfs/mfs.a; ../../../../../../../../lib/twrk60n512.iar/release/shell/shell.a; ../../../../../../../../lib/twrk60n512.iar/release/usb/usbh.a
  group Sources
    ../../../: audio_speaker.c audio_speaker.h sh_audio.c sh_audio.h sd_card.h sd_card.c hidkeyboard.h hidkeyboard.c main.c usb_classes.c usb_classes.h wav.c wav.h
