# IAR project speaker_host_twrk40d100m.ewp, settings and files
configuration int flash debug (ARM, debug)
  General.OGChipSelectEditMenu: MK40DX256Zxxx10 Freescale MK40DX256Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../lib/twrk40d100m.iar/debug/bsp/Generated_Code; ../../../../../../../../lib/twrk40d100m.iar/debug; ../../../../../../../../lib/twrk40d100m.iar/debug/bsp; ../../../../../../../../lib/twrk40d100m.iar/debug/psp; ../../../../../../../../lib/twrk40d100m.iar/debug/mfs; ../../../../../../../../lib/twrk40d100m.iar/debug/shell; ../../../../../../../../lib/twrk40d100m.iar/debug/usb
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: ../../../../../../../../lib/twrk40d100m.iar/debug/bsp/Generated_Code; ../../../../../../../../lib/twrk40d100m.iar/debug; ../../../../../../../../lib/twrk40d100m.iar/debug/bsp; ../../../../../../../../lib/twrk40d100m.iar/debug/psp; ../../../../../../../../lib/twrk40d100m.iar/debug/mfs; ../../../../../../../../lib/twrk40d100m.iar/debug/shell; ../../../../../../../../lib/twrk40d100m.iar/debug/usb
  OBJCOPY.OOCOutputFile: twrk40d100m.srec
  ILINK.IlinkOutputFile: speaker_host.out
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrk40d100m.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/twrk40d100m.iar/debug/bsp/bsp.a; ../../../../../../../../lib/twrk40d100m.iar/debug/psp/psp.a; ../../../../../../../../lib/twrk40d100m.iar/debug/mfs/mfs.a; ../../../../../../../../lib/twrk40d100m.iar/debug/shell/shell.a; ../../../../../../../../lib/twrk40d100m.iar/debug/usb/usbh.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration int flash release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../lib/twrk40d100m.iar/release/bsp/Generated_Code; ../../../../../../../../lib/twrk40d100m.iar/release; ../../../../../../../../lib/twrk40d100m.iar/release/bsp; ../../../../../../../../lib/twrk40d100m.iar/release/psp; ../../../../../../../../lib/twrk40d100m.iar/release/mfs; ../../../../../../../../lib/twrk40d100m.iar/release/shell; ../../../../../../../../lib/twrk40d100m.iar/release/usb
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG=1
  AARM.AUserIncludes: ../../../../../../../../lib/twrk40d100m.iar/release/bsp/Generated_Code; ../../../../../../../../lib/twrk40d100m.iar/release; ../../../../../../../../lib/twrk40d100m.iar/release/bsp; ../../../../../../../../lib/twrk40d100m.iar/release/psp; ../../../../../../../../lib/twrk40d100m.iar/release/mfs; ../../../../../../../../lib/twrk40d100m.iar/release/shell; ../../../../../../../../lib/twrk40d100m.iar/release/usb
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrk40d100m.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/twrk40d100m.iar/release/bsp/bsp.a; ../../../../../../../../lib/twrk40d100m.iar/release/psp/psp.a; ../../../../../../../../lib/twrk40d100m.iar/release/mfs/mfs.a; ../../../../../../../../lib/twrk40d100m.iar/release/shell/shell.a; ../../../../../../../../lib/twrk40d100m.iar/release/usb/usbh.a
  group Sources
    ../../../: audio_speaker.c audio_speaker.h sh_audio.c sh_audio.h sd_card.h sd_card.c hidkeyboard.h hidkeyboard.c main.c usb_classes.c usb_classes.h wav.c wav.h
