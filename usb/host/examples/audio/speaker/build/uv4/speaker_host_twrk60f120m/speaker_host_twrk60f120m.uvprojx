# Keil uVision project speaker_host_twrk60f120m.uvprojx, settings and files
target int flash debug (ARM-ADS)
  device: MK60FN1M0xxx12 Freescale Semiconductor
  cpu: CPUTYPE("Cortex-M4.fp")
  output: speaker_host.axf +hex
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: -J../../.. 
-J../../../../../../../../lib/twrk60f120m.uv4/debug/bsp/Generated_Code 
-J../../../../../../../../lib/twrk60f120m.uv4/debug 
-J../../../../../../../../lib/twrk60f120m.uv4/debug/bsp 
-J../../../../../../../../lib/twrk60f120m.uv4/debug/psp 
-J../../../../../../../../lib/twrk60f120m.uv4/debug/mfs 
-J../../../../../../../../lib/twrk60f120m.uv4/debug/shell 
-J../../../../../../../../lib/twrk60f120m.uv4/debug/usb 
-J#J 
--library_interface=none 
--library_type=standardlib 
--c99 
--diag_suppress=1296,186
  c include: ../../..;../../../../../../../../lib/twrk60f120m.uv4/debug/bsp/Generated_Code;../../../../../../../../lib/twrk60f120m.uv4/debug;../../../../../../../../lib/twrk60f120m.uv4/debug/bsp;../../../../../../../../lib/twrk60f120m.uv4/debug/psp;../../../../../../../../lib/twrk60f120m.uv4/debug/mfs;../../../../../../../../lib/twrk60f120m.uv4/debug/shell;../../../../../../../../lib/twrk60f120m.uv4/debug/usb
  asm misc: --cpreproc_opts '-D_DEBUG=1' --cpreproc
  asm include: ../../../../../../../../lib/twrk60f120m.uv4/debug/bsp/Generated_Code;../../../../../../../../lib/twrk60f120m.uv4/debug;../../../../../../../../lib/twrk60f120m.uv4/debug/bsp;../../../../../../../../lib/twrk60f120m.uv4/debug/psp;../../../../../../../../lib/twrk60f120m.uv4/debug/mfs;../../../../../../../../lib/twrk60f120m.uv4/debug/shell;../../../../../../../../lib/twrk60f120m.uv4/debug/usb
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../../../../../lib/twrk60f120m.uv4/debug/bsp/intflash.scf
  link misc: ../../../../../../../../lib/twrk60f120m.uv4/debug/bsp/bsp.lib 
../../../../../../../../lib/twrk60f120m.uv4/debug/psp/psp.lib 
../../../../../../../../lib/twrk60f120m.uv4/debug/mfs/mfs.lib 
../../../../../../../../lib/twrk60f120m.uv4/debug/shell/shell.lib 
../../../../../../../../lib/twrk60f120m.uv4/debug/usb/usbh.lib 
../../../../../../../../lib/twrk60f120m.uv4/debug/bsp/bsp.lib(vectors.o) 
../../../../../../../../lib/twrk60f120m.uv4/debug/psp/psp.lib(linker_symbols.o) 
--keep linker_symbols.o(KERNEL_DATA_START) 
--keep linker_symbols.o(KERNEL_DATA_END) 
--keep linker_symbols.o(BOOT_STACK) 
--keep vectors.o(.vectors_rom) 
--remove 
--autoat 
--entry 
__boot
  group Sources
    ../../../: audio_speaker.c audio_speaker.h sh_audio.c sh_audio.h sd_card.h sd_card.c hidkeyboard.h hidkeyboard.c main.c usb_classes.c usb_classes.h wav.c wav.h
target int flash release (ARM-ADS)
  device: MK60FN1M0xxx12 Freescale Semiconductor
  cpu: CPUTYPE("Cortex-M4.fp")
  output: speaker_host.axf +hex
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG=1
  c misc: -J../../.. 
-J../../../../../../../../lib/twrk60f120m.uv4/release/bsp/Generated_Code 
-J../../../../../../../../lib/twrk60f120m.uv4/release 
-J../../../../../../../../lib/twrk60f120m.uv4/release/bsp 
-J../../../../../../../../lib/twrk60f120m.uv4/release/psp 
-J../../../../../../../../lib/twrk60f120m.uv4/release/mfs 
-J../../../../../../../../lib/twrk60f120m.uv4/release/shell 
-J../../../../../../../../lib/twrk60f120m.uv4/release/usb 
-J#J 
--library_interface=none 
--library_type=standardlib 
--c99 
--diag_suppress=1296,186
  c include: ../../..;../../../../../../../../lib/twrk60f120m.uv4/release/bsp/Generated_Code;../../../../../../../../lib/twrk60f120m.uv4/release;../../../../../../../../lib/twrk60f120m.uv4/release/bsp;../../../../../../../../lib/twrk60f120m.uv4/release/psp;../../../../../../../../lib/twrk60f120m.uv4/release/mfs;../../../../../../../../lib/twrk60f120m.uv4/release/shell;../../../../../../../../lib/twrk60f120m.uv4/release/usb
  asm misc: --cpreproc_opts '-DNDEBUG=1' --cpreproc
  asm include: ../../../../../../../../lib/twrk60f120m.uv4/release/bsp/Generated_Code;../../../../../../../../lib/twrk60f120m.uv4/release;../../../../../../../../lib/twrk60f120m.uv4/release/bsp;../../../../../../../../lib/twrk60f120m.uv4/release/psp;../../../../../../../../lib/twrk60f120m.uv4/release/mfs;../../../../../../../../lib/twrk60f120m.uv4/release/shell;../../../../../../../../lib/twrk60f120m.uv4/release/usb
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../../../../../lib/twrk60f120m.uv4/release/bsp/intflash.scf
  link misc: ../../../../../../../../lib/twrk60f120m.uv4/release/bsp/bsp.lib 
../../../../../../../../lib/twrk60f120m.uv4/release/psp/psp.lib 
../../../../../../../../lib/twrk60f120m.uv4/release/mfs/mfs.lib 
../../../../../../../../lib/twrk60f120m.uv4/release/shell/shell.lib 
../../../../../../../../lib/twrk60f120m.uv4/release/usb/usbh.lib 
../../../../../../../../lib/twrk60f120m.uv4/release/bsp/bsp.lib(vectors.o) 
../../../../../../../../lib/twrk60f120m.uv4/release/psp/psp.lib(linker_symbols.o) 
--keep linker_symbols.o(KERNEL_DATA_START) 
--keep linker_symbols.o(KERNEL_DATA_END) 
--keep linker_symbols.o(BOOT_STACK) 
--keep vectors.o(.vectors_rom) 
--remove 
--autoat 
--entry 
__boot
