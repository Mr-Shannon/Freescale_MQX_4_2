# IAR project hid_kbd_mouse_kwikstikk40x256.ewp, settings and files
configuration int flash debug (ARM, debug)
  General.OGChipSelectEditMenu: MK40DX256Zxxx10 Freescale MK40DX256Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../lib/kwikstikk40x256.iar/debug/bsp/Generated_Code; ../../../../../../../../lib/kwikstikk40x256.iar/debug; ../../../../../../../../lib/kwikstikk40x256.iar/debug/bsp; ../../../../../../../../lib/kwikstikk40x256.iar/debug/psp; ../../../../../../../../lib/kwikstikk40x256.iar/debug/usb
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: ../../../../../../../../lib/kwikstikk40x256.iar/debug/bsp/Generated_Code; ../../../../../../../../lib/kwikstikk40x256.iar/debug; ../../../../../../../../lib/kwikstikk40x256.iar/debug/bsp; ../../../../../../../../lib/kwikstikk40x256.iar/debug/psp; ../../../../../../../../lib/kwikstikk40x256.iar/debug/usb
  OBJCOPY.OOCOutputFile: kwikstikk40x256.srec
  ILINK.IlinkOutputFile: hid_kbd_mouse.out
  ILINK.IlinkIcfFile: ../../../../../../../../lib/kwikstikk40x256.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/kwikstikk40x256.iar/debug/bsp/bsp.a; ../../../../../../../../lib/kwikstikk40x256.iar/debug/psp/psp.a; ../../../../../../../../lib/kwikstikk40x256.iar/debug/usb/usbh.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration int flash release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../lib/kwikstikk40x256.iar/release/bsp/Generated_Code; ../../../../../../../../lib/kwikstikk40x256.iar/release; ../../../../../../../../lib/kwikstikk40x256.iar/release/bsp; ../../../../../../../../lib/kwikstikk40x256.iar/release/psp; ../../../../../../../../lib/kwikstikk40x256.iar/release/usb
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG=1
  AARM.AUserIncludes: ../../../../../../../../lib/kwikstikk40x256.iar/release/bsp/Generated_Code; ../../../../../../../../lib/kwikstikk40x256.iar/release; ../../../../../../../../lib/kwikstikk40x256.iar/release/bsp; ../../../../../../../../lib/kwikstikk40x256.iar/release/psp; ../../../../../../../../lib/kwikstikk40x256.iar/release/usb
  ILINK.IlinkIcfFile: ../../../../../../../../lib/kwikstikk40x256.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/kwikstikk40x256.iar/release/bsp/bsp.a; ../../../../../../../../lib/kwikstikk40x256.iar/release/psp/psp.a; ../../../../../../../../lib/kwikstikk40x256.iar/release/usb/usbh.a
  group Sources
    ../../../: hidkeyboard.c hidkeyboard.h hidmouse.c hidmouse.h main.c usb_classes.c usb_classes.h
