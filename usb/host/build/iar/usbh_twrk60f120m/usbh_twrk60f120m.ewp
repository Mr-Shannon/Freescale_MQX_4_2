# IAR project usbh_twrk60f120m.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../../source/classes/audio; ../../../source/classes/cdc; ../../../../common/include; ../../../source/host/ehci; ../../../source/classes/hid; ../../../source/classes/hub; ../../../source/include; ../../../source/host/khci; ../../../source/classes/msd; ../../../source/classes/msd/mfs; ../../../source/rtos/mqx; ../../../source/classes/phdc; ../../../source/classes/printer; ../../../../../mqx/source/io/adc/kadc; ../../../../../mqx/source/io/adc; ../../../../../mqx/source/io/cm; ../../../../../config/twrk60f120m; ../../../../../mqx/source/io/dma; ../../../../../mqx/source/io/enet/macnet; ../../../../../mqx/source/io/enet/phy; ../../../../../mqx/source/io/enet; ../../../../../mqx/source/io/esdhc; ../../../../../mqx/source/io/flashx/freescale; ../../../../../mqx/source/io/flashx; ../../../../../mqx/source/io/flashx/amd; ../../../../../mqx/source/io/flashx/fujitsu; ../../../../../mqx/source/io/flashx/spansion; ../../../../../mqx/source/io/flashx/atmel; ../../../../../mqx/source/io/flashx/istrata; ../../../../../mqx/source/io/flashx/sharp; ../../../../../mqx/source/io/can/flexcan; ../../../../../mqx/source/io/gpio/kgpio; ../../../../../mqx/source/io/gpio; ../../../../../mqx/source/io/hwtimer; ../../../../../mqx/source/io/i2c; ../../../../../mqx/source/io/i2c/polled; ../../../../../mqx/source/io/i2c/int; ../../../../../mqx/source/bsp/twrk60f120m; ../../../../../config/common; ../../../../../mqx/source/include; ../../../../../mqx/source/bsp/twrk60f120m; ../../../../../mqx/source/io/enet; ../../../../../mqx/source/io/debug; ../../../../../mqx/source/io/io_mem; ../../../../../mqx/source/io/io_null; ../../../../../mqx/source/io/pipe; ../../../../../mqx/source/io/lpm; ../../../../../mqx/source/io/lwadc; ../../../../../mqx/source/io/lwgpio; ../../../../../mqx/source/io/nandflash/nfc; ../../../../../mqx/source/io/nandflash; ../../../../../mqx/source/io/pcb; ../../../../../mqx/source/io/pcb/mqxa; ../../../../../mqx/source/io/pccard; ../../../../../mqx/source/io/pcflash; ../../../../../mqx/source/io/rtc; ../../../../../mqx/source/io/sai; ../../../../../mqx/source/io/sai/dma; ../../../../../mqx/source/io/sdcard/sdcard_esdhc; ../../../../../mqx/source/io/sdcard/sdcard_spi; ../../../../../mqx/source/io/sdcard; ../../../../../mqx/source/io/serial; ../../../../../mqx/source/io/spi; ../../../../../mqx/source/io/tchres; ../../../../../mqx/source/io/tfs; ../../../../../mqx/source/io/timer; ../../../../../mqx/source/io/usb; ../../../../../mqx/source/io/usb_dcd; ../../../../../mqx/source/io/usb_dcd/polled; ../../../../../mqx/source/io/usb_dcd/int; ../../../../../mqx/source/psp/cortex_m/compiler/iar; ../../../../../mqx/source/psp/cortex_m/cpu; ../../../../../mqx/source/psp/cortex_m; ../../../../../config/twrk60f120m; ../../../../../config/common; ../../../../../mqx/source/include; ../../../../../mqx/source/tad; ../../../../../mfs/source/include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: ../../../../../mqx/source/io/debug; ../../../../../mqx/source/psp/cortex_m/compiler/iar; ../../../../../mqx/source/psp/cortex_m; ../../../../../mqx/source/psp/cortex_m/core/M4; ../../../../../config/twrk60f120m; ../../../../../mqx/source/include; ../../../../../config/common
  postbuild: "../../bat/usbh_twrk60f120m.bat" "../../../../.." "../../../../../lib/twrk60f120m.iar/debug/usb" iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG=1
  postbuild: "../../bat/usbh_twrk60f120m.bat" "../../../../.." "../../../../../lib/twrk60f120m.iar/release/usb" iar
  ILINK.IlinkOutputFile: libgeneric.out
  group USB Class Drivers/audio
    ../../../source/classes/audio/: usb_host_audio.c usb_host_audio.h usb_host_audio_intf.c
  group USB Class Drivers/cdc
    ../../../source/classes/cdc/: usb_host_cdc.c usb_host_cdc.h usb_host_cdc_intf.c
  group USB Class Drivers/hid
    ../../../source/classes/hid/: usb_host_hid.c usb_host_hid.h
  group USB Class Drivers/hub
    ../../../source/classes/hub/: usb_host_hub.c usb_host_hub.h usb_host_hub_prv.h usb_host_hub_sm.c usb_host_hub_sm.h
  group USB Class Drivers/msd
    ../../../source/classes/msd/: usb_host_msd_bo.c usb_host_msd_bo.h usb_host_msd_queue.c usb_host_msd_ufi.c usb_host_msd_ufi.h
    ../../../source/classes/msd/mfs/: usbmfs.c usbmfs.h usbmfspr.h
  group USB Class Drivers/phdc
    ../../../source/classes/phdc/: usb_host_phdc.c usb_host_phdc.h
  group USB Class Drivers/printer
    ../../../source/classes/printer/: usb_host_printer.c usb_host_printer.h
  group USB Host/include
    ../../../../common/include/: usb.h usb_debug.h usb_desc.h usb_error.h usb_misc.h usb_types.h usb_misc_prv.h usb_prv.h
    ../../../source/include/: host_ch9.h host_close.h host_cnfg.h host_cnl.h host_common.h host_dev_list.h host_main.h host_rcv.h host_shut.h host_snd.h hostapi.h
  group USB Host/os
    ../../../source/rtos/mqx/: mqx_host.h mqx_dll.c mqx_dll.h usb_mqx.c usb_mqx.h
  group USB Host/source
    ../../../source/host/: host_ch9.c host_close.c host_cnl.c host_common.c host_dev_list.c host_main.c host_rcv.c host_shut.c host_snd.c
  group USB Low Level Driver/ehci
    ../../../source/host/ehci/: ehci.h ehci_bw.c ehci_bw.h ehci_cache.h ehci_cncl.c ehci_cncl.h ehci_intr.c ehci_intr.h ehci_iso.c ehci_iso.h ehci_main.c ehci_main.h ehci_shut.c ehci_shut.h ehci_utl.c ehci_utl.h
  group USB Low Level Driver/khci
    ../../../source/host/khci/: khci.c khci.h
