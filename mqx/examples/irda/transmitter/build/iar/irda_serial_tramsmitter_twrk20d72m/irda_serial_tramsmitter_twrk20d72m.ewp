# IAR project irda_serial_tramsmitter_twrk20d72m.ewp, settings and files
configuration int flash debug (ARM, debug)
  General.OGChipSelectEditMenu: MK20DX256Zxxx10 Freescale MK20DX256Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../../..; ../../../../../../../lib/twrk20d72m.iar/debug/bsp/Generated_Code; ../../../../../../../lib/twrk20d72m.iar/debug; ../../../../../../../lib/twrk20d72m.iar/debug/bsp; ../../../../../../../lib/twrk20d72m.iar/debug/psp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: ../../../../../../../lib/twrk20d72m.iar/debug/bsp/Generated_Code; ../../../../../../../lib/twrk20d72m.iar/debug; ../../../../../../../lib/twrk20d72m.iar/debug/bsp; ../../../../../../../lib/twrk20d72m.iar/debug/psp
  OBJCOPY.OOCOutputFile: twrk20d72m.srec
  ILINK.IlinkOutputFile: irda_serial_tramsmitter.out
  ILINK.IlinkIcfFile: ../../../../../../../lib/twrk20d72m.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../lib/twrk20d72m.iar/debug/bsp/bsp.a; ../../../../../../../lib/twrk20d72m.iar/debug/psp/psp.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration int flash release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1
  ICCARM.CCIncludePath2: ../../../..; ../../../../../../../lib/twrk20d72m.iar/release/bsp/Generated_Code; ../../../../../../../lib/twrk20d72m.iar/release; ../../../../../../../lib/twrk20d72m.iar/release/bsp; ../../../../../../../lib/twrk20d72m.iar/release/psp
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG=1
  AARM.AUserIncludes: ../../../../../../../lib/twrk20d72m.iar/release/bsp/Generated_Code; ../../../../../../../lib/twrk20d72m.iar/release; ../../../../../../../lib/twrk20d72m.iar/release/bsp; ../../../../../../../lib/twrk20d72m.iar/release/psp
  ILINK.IlinkIcfFile: ../../../../../../../lib/twrk20d72m.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../lib/twrk20d72m.iar/release/bsp/bsp.a; ../../../../../../../lib/twrk20d72m.iar/release/psp/psp.a
  group Sources
    ../../../: main.c
    ../../../../: main.h
