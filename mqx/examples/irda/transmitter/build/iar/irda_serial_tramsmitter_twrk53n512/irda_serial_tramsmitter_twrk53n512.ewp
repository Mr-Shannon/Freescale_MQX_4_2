# IAR project irda_serial_tramsmitter_twrk53n512.ewp, settings and files
configuration int flash debug (ARM, debug)
  General.OGChipSelectEditMenu: MK53DN512Zxxx10 Freescale MK53DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../../..; ../../../../../../../lib/twrk53n512.iar/debug/bsp/Generated_Code; ../../../../../../../lib/twrk53n512.iar/debug; ../../../../../../../lib/twrk53n512.iar/debug/bsp; ../../../../../../../lib/twrk53n512.iar/debug/psp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: ../../../../../../../lib/twrk53n512.iar/debug/bsp/Generated_Code; ../../../../../../../lib/twrk53n512.iar/debug; ../../../../../../../lib/twrk53n512.iar/debug/bsp; ../../../../../../../lib/twrk53n512.iar/debug/psp
  ILINK.IlinkOutputFile: irda_serial_tramsmitter.out
  ILINK.IlinkIcfFile: ../../../../../../../lib/twrk53n512.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../lib/twrk53n512.iar/debug/bsp/bsp.a; ../../../../../../../lib/twrk53n512.iar/debug/psp/psp.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration int flash release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1
  ICCARM.CCIncludePath2: ../../../..; ../../../../../../../lib/twrk53n512.iar/release/bsp/Generated_Code; ../../../../../../../lib/twrk53n512.iar/release; ../../../../../../../lib/twrk53n512.iar/release/bsp; ../../../../../../../lib/twrk53n512.iar/release/psp
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG=1
  AARM.AUserIncludes: ../../../../../../../lib/twrk53n512.iar/release/bsp/Generated_Code; ../../../../../../../lib/twrk53n512.iar/release; ../../../../../../../lib/twrk53n512.iar/release/bsp; ../../../../../../../lib/twrk53n512.iar/release/psp
  ILINK.IlinkIcfFile: ../../../../../../../lib/twrk53n512.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../lib/twrk53n512.iar/release/bsp/bsp.a; ../../../../../../../lib/twrk53n512.iar/release/psp/psp.a
  group Sources
    ../../../: main.c
    ../../../../: main.h
