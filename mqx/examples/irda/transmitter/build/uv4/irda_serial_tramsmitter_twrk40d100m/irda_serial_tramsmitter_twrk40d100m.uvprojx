# Keil uVision project irda_serial_tramsmitter_twrk40d100m.uvprojx, settings and files
target int flash debug (ARM-ADS)
  device: MK40DX256xxx10 Freescale Semiconductor
  cpu: CPUTYPE("Cortex-M4")
  output: irda_serial_tramsmitter.axf +hex
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: -J../../../.. 
-J../../../../../../../lib/twrk40d100m.uv4/debug/bsp/Generated_Code 
-J../../../../../../../lib/twrk40d100m.uv4/debug 
-J../../../../../../../lib/twrk40d100m.uv4/debug/bsp 
-J../../../../../../../lib/twrk40d100m.uv4/debug/psp 
-J#J 
--library_interface=none 
--library_type=standardlib 
--c99 
--diag_suppress=1296,186
  c include: ../../../..;../../../../../../../lib/twrk40d100m.uv4/debug/bsp/Generated_Code;../../../../../../../lib/twrk40d100m.uv4/debug;../../../../../../../lib/twrk40d100m.uv4/debug/bsp;../../../../../../../lib/twrk40d100m.uv4/debug/psp
  asm misc: --cpreproc_opts '-D_DEBUG=1' --cpreproc
  asm include: ../../../../../../../lib/twrk40d100m.uv4/debug/bsp/Generated_Code;../../../../../../../lib/twrk40d100m.uv4/debug;../../../../../../../lib/twrk40d100m.uv4/debug/bsp;../../../../../../../lib/twrk40d100m.uv4/debug/psp
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: ../../../../../../../lib/twrk40d100m.uv4/debug/bsp/intflash.scf
  link misc: ../../../../../../../lib/twrk40d100m.uv4/debug/bsp/bsp.lib 
../../../../../../../lib/twrk40d100m.uv4/debug/psp/psp.lib 
../../../../../../../lib/twrk40d100m.uv4/debug/bsp/bsp.lib(vectors.o) 
../../../../../../../lib/twrk40d100m.uv4/debug/psp/psp.lib(linker_symbols.o) 
--keep linker_symbols.o(KERNEL_DATA_START) 
--keep linker_symbols.o(KERNEL_DATA_END) 
--keep linker_symbols.o(BOOT_STACK) 
--keep vectors.o(.vectors_rom) 
--remove 
--autoat 
--entry 
__boot
  group Sources
    ../../../: main.c
    ../../../../: main.h
target int flash release (ARM-ADS)
  device: MK40DX256xxx10 Freescale Semiconductor
  cpu: CPUTYPE("Cortex-M4")
  output: irda_serial_tramsmitter.axf +hex
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG=1
  c misc: -J../../../.. 
-J../../../../../../../lib/twrk40d100m.uv4/release/bsp/Generated_Code 
-J../../../../../../../lib/twrk40d100m.uv4/release 
-J../../../../../../../lib/twrk40d100m.uv4/release/bsp 
-J../../../../../../../lib/twrk40d100m.uv4/release/psp 
-J#J 
--library_interface=none 
--library_type=standardlib 
--c99 
--diag_suppress=1296,186
  c include: ../../../..;../../../../../../../lib/twrk40d100m.uv4/release/bsp/Generated_Code;../../../../../../../lib/twrk40d100m.uv4/release;../../../../../../../lib/twrk40d100m.uv4/release/bsp;../../../../../../../lib/twrk40d100m.uv4/release/psp
  asm misc: --cpreproc_opts '-DNDEBUG=1' --cpreproc
  asm include: ../../../../../../../lib/twrk40d100m.uv4/release/bsp/Generated_Code;../../../../../../../lib/twrk40d100m.uv4/release;../../../../../../../lib/twrk40d100m.uv4/release/bsp;../../../../../../../lib/twrk40d100m.uv4/release/psp
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: ../../../../../../../lib/twrk40d100m.uv4/release/bsp/intflash.scf
  link misc: ../../../../../../../lib/twrk40d100m.uv4/release/bsp/bsp.lib 
../../../../../../../lib/twrk40d100m.uv4/release/psp/psp.lib 
../../../../../../../lib/twrk40d100m.uv4/release/bsp/bsp.lib(vectors.o) 
../../../../../../../lib/twrk40d100m.uv4/release/psp/psp.lib(linker_symbols.o) 
--keep linker_symbols.o(KERNEL_DATA_START) 
--keep linker_symbols.o(KERNEL_DATA_END) 
--keep linker_symbols.o(BOOT_STACK) 
--keep vectors.o(.vectors_rom) 
--remove 
--autoat 
--entry 
__boot
