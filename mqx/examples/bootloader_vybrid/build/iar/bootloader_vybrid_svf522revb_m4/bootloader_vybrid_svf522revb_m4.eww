<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>bsp_svf522revb_m4</project><configuration>debug</configuration></member><member><project>psp_svf522revb_m4</project><configuration>debug</configuration></member><member><project>mfs_svf522revb_m4</project><configuration>debug</configuration></member><member><project>bootloader_vybrid_svf522revb_m4</project><configuration>int ram debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>bsp_svf522revb_m4</project><configuration>release</configuration></member><member><project>psp_svf522revb_m4</project><configuration>release</configuration></member><member><project>mfs_svf522revb_m4</project><configuration>release</configuration></member><member><project>bootloader_vybrid_svf522revb_m4</project><configuration>int ram release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\..\..\build\iar\bsp_svf522revb_m4\bsp_svf522revb_m4.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\build\iar\psp_svf522revb_m4\psp_svf522revb_m4.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\mfs\build\iar\mfs_svf522revb_m4\mfs_svf522revb_m4.ewp</path></project><project><path>$WS_DIR$\bootloader_vybrid_svf522revb_m4.ewp</path></project></workspace>
