<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>bsp_twrvf65gs10_a5</project><configuration>debug</configuration></member><member><project>psp_twrvf65gs10_a5</project><configuration>debug</configuration></member><member><project>ipc_shmem_twrvf65gs10_a5</project><configuration>int ram debug</configuration></member><member><project>ipc_shmem_twrvf65gs10_a5</project><configuration>ddr debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>bsp_twrvf65gs10_a5</project><configuration>release</configuration></member><member><project>psp_twrvf65gs10_a5</project><configuration>release</configuration></member><member><project>ipc_shmem_twrvf65gs10_a5</project><configuration>int ram release</configuration></member><member><project>ipc_shmem_twrvf65gs10_a5</project><configuration>ddr release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\..\..\..\build\iar\bsp_twrvf65gs10_a5\bsp_twrvf65gs10_a5.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\build\iar\psp_twrvf65gs10_a5\psp_twrvf65gs10_a5.ewp</path></project><project><path>$WS_DIR$\ipc_shmem_twrvf65gs10_a5.ewp</path></project></workspace>
