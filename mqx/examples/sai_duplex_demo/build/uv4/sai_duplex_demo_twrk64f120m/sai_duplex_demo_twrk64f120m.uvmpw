<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <WorkspaceName>WorkSpace</WorkspaceName>
<project><PathAndName>..\..\..\..\..\build\uv4\bsp_twrk64f120m\bsp_twrk64f120m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\build\uv4\psp_twrk64f120m\psp_twrk64f120m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\..\mfs\build\uv4\mfs_twrk64f120m\mfs_twrk64f120m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\..\shell\build\uv4\shell_twrk64f120m\shell_twrk64f120m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>sai_duplex_demo_twrk64f120m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project></ProjectWorkspace>
