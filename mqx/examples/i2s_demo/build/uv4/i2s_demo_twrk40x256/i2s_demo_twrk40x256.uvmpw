<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <WorkspaceName>WorkSpace</WorkspaceName>
<project><PathAndName>..\..\..\..\..\build\uv4\bsp_twrk40x256\bsp_twrk40x256.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\build\uv4\psp_twrk40x256\psp_twrk40x256.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\..\mfs\build\uv4\mfs_twrk40x256\mfs_twrk40x256.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\..\shell\build\uv4\shell_twrk40x256\shell_twrk40x256.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>i2s_demo_twrk40x256.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project></ProjectWorkspace>
