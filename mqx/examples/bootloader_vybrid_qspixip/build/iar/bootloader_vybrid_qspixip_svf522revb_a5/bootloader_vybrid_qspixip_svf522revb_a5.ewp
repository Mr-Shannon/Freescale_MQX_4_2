# IAR project bootloader_vybrid_qspixip_svf522revb_a5.ewp, settings and files
configuration int ram debug (ARM, debug)
  General.OGChipSelectEditMenu: SVF522R3K1CMK4_A5 Freescale SVF522R3K1CMK4_A5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../..; ../../../md5; ../../../../qspi; ../../../../../../lib/svf522revb_a5.iar/debug/bsp/Generated_Code; ../../../../../../lib/svf522revb_a5.iar/debug; ../../../../../../lib/svf522revb_a5.iar/debug/bsp; ../../../../../../lib/svf522revb_a5.iar/debug/psp; ../../../../../../lib/svf522revb_a5.iar/debug/mfs
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: ../../../../../../lib/svf522revb_a5.iar/debug/bsp/Generated_Code; ../../../../../../lib/svf522revb_a5.iar/debug; ../../../../../../lib/svf522revb_a5.iar/debug/bsp; ../../../../../../lib/svf522revb_a5.iar/debug/psp; ../../../../../../lib/svf522revb_a5.iar/debug/mfs
  OBJCOPY.OOCOutputFile: svf522revb_a5.bin
  ILINK.IlinkOutputFile: bootloader_vybrid_qspixip.out
  ILINK.IlinkIcfFile: ../../../sram_iar_a5.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/svf522revb_a5.iar/debug/bsp/bsp.a; ../../../../../../lib/svf522revb_a5.iar/debug/psp/psp.a; ../../../../../../lib/svf522revb_a5.iar/debug/mfs/mfs.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration int ram release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1
  ICCARM.CCIncludePath2: ../../..; ../../../md5; ../../../../qspi; ../../../../../../lib/svf522revb_a5.iar/release/bsp/Generated_Code; ../../../../../../lib/svf522revb_a5.iar/release; ../../../../../../lib/svf522revb_a5.iar/release/bsp; ../../../../../../lib/svf522revb_a5.iar/release/psp; ../../../../../../lib/svf522revb_a5.iar/release/mfs
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG=1
  AARM.AUserIncludes: ../../../../../../lib/svf522revb_a5.iar/release/bsp/Generated_Code; ../../../../../../lib/svf522revb_a5.iar/release; ../../../../../../lib/svf522revb_a5.iar/release/bsp; ../../../../../../lib/svf522revb_a5.iar/release/psp; ../../../../../../lib/svf522revb_a5.iar/release/mfs
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/svf522revb_a5.iar/release/bsp/bsp.a; ../../../../../../lib/svf522revb_a5.iar/release/psp/psp.a; ../../../../../../lib/svf522revb_a5.iar/release/mfs/mfs.a
  group Sources
    ../../../: boot.c quadspi_boot.c quadspi_boot.h iniparser.c iniparser.h
    ../../../../qspi/: qspi_memory.c qspi_memory.h
  group Sources/md5
    ../../../md5/: md5.c md5.h
