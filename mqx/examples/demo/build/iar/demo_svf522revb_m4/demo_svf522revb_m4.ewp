# IAR project demo_svf522revb_m4.ewp, settings and files
configuration int ram debug (ARM, debug)
  General.OGChipSelectEditMenu: SVF522R3K1CMK4_M4 Freescale SVF522R3K1CMK4_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../..; ../../../../../../lib/svf522revb_m4.iar/debug/bsp/Generated_Code; ../../../../../../lib/svf522revb_m4.iar/debug; ../../../../../../lib/svf522revb_m4.iar/debug/bsp; ../../../../../../lib/svf522revb_m4.iar/debug/psp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: ../../../../../../lib/svf522revb_m4.iar/debug/bsp/Generated_Code; ../../../../../../lib/svf522revb_m4.iar/debug; ../../../../../../lib/svf522revb_m4.iar/debug/bsp; ../../../../../../lib/svf522revb_m4.iar/debug/psp
  OBJCOPY.OOCOutputFile: svf522revb_m4.bin
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: ../../../../../../lib/svf522revb_m4.iar/debug/bsp/ram.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/svf522revb_m4.iar/debug/bsp/bsp.a; ../../../../../../lib/svf522revb_m4.iar/debug/psp/psp.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration int ram release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1
  ICCARM.CCIncludePath2: ../../..; ../../../../../../lib/svf522revb_m4.iar/release/bsp/Generated_Code; ../../../../../../lib/svf522revb_m4.iar/release; ../../../../../../lib/svf522revb_m4.iar/release/bsp; ../../../../../../lib/svf522revb_m4.iar/release/psp
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG=1
  AARM.AUserIncludes: ../../../../../../lib/svf522revb_m4.iar/release/bsp/Generated_Code; ../../../../../../lib/svf522revb_m4.iar/release; ../../../../../../lib/svf522revb_m4.iar/release/bsp; ../../../../../../lib/svf522revb_m4.iar/release/psp
  ILINK.IlinkIcfFile: ../../../../../../lib/svf522revb_m4.iar/release/bsp/ram.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/svf522revb_m4.iar/release/bsp/bsp.a; ../../../../../../lib/svf522revb_m4.iar/release/psp/psp.a
  group Sources
    ../../../: ttl.c sender.c semb.c sema.c responde.c mutexb.c mutexa.c main.c eventb.c eventa.c demo.h demo.dsn demo.c btimesli.c atimesli.c
