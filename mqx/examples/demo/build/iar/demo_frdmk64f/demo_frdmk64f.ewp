# IAR project demo_frdmk64f.ewp, settings and files
configuration int flash debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../..; ../../../../../../lib/frdmk64f.iar/debug/bsp/Generated_Code; ../../../../../../lib/frdmk64f.iar/debug; ../../../../../../lib/frdmk64f.iar/debug/bsp; ../../../../../../lib/frdmk64f.iar/debug/psp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: ../../../../../../lib/frdmk64f.iar/debug/bsp/Generated_Code; ../../../../../../lib/frdmk64f.iar/debug; ../../../../../../lib/frdmk64f.iar/debug/bsp; ../../../../../../lib/frdmk64f.iar/debug/psp
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: ../../../../../../lib/frdmk64f.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/frdmk64f.iar/debug/bsp/bsp.a; ../../../../../../lib/frdmk64f.iar/debug/psp/psp.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration int flash release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1
  ICCARM.CCIncludePath2: ../../..; ../../../../../../lib/frdmk64f.iar/release/bsp/Generated_Code; ../../../../../../lib/frdmk64f.iar/release; ../../../../../../lib/frdmk64f.iar/release/bsp; ../../../../../../lib/frdmk64f.iar/release/psp
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG=1
  AARM.AUserIncludes: ../../../../../../lib/frdmk64f.iar/release/bsp/Generated_Code; ../../../../../../lib/frdmk64f.iar/release; ../../../../../../lib/frdmk64f.iar/release/bsp; ../../../../../../lib/frdmk64f.iar/release/psp
  ILINK.IlinkIcfFile: ../../../../../../lib/frdmk64f.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/frdmk64f.iar/release/bsp/bsp.a; ../../../../../../lib/frdmk64f.iar/release/psp/psp.a
  group Sources
    ../../../: ttl.c sender.c semb.c sema.c responde.c mutexb.c mutexa.c main.c eventb.c eventa.c demo.h demo.dsn demo.c btimesli.c atimesli.c
