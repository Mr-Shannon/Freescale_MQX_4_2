# IAR project timing_twrvf65gs10_a5.ewp, settings and files
configuration ddr debug (ARM, debug)
  General.OGChipSelectEditMenu: VF6xx_A5 Freescale VF6xx_A5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../..; ../../../../../../source/include; ../../../../../../../lib/twrvf65gs10_a5.iar/debug/bsp/Generated_Code; ../../../../../../../lib/twrvf65gs10_a5.iar/debug; ../../../../../../../lib/twrvf65gs10_a5.iar/debug/bsp; ../../../../../../../lib/twrvf65gs10_a5.iar/debug/psp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: ../../../../../../../lib/twrvf65gs10_a5.iar/debug/bsp/Generated_Code; ../../../../../../../lib/twrvf65gs10_a5.iar/debug; ../../../../../../../lib/twrvf65gs10_a5.iar/debug/bsp; ../../../../../../../lib/twrvf65gs10_a5.iar/debug/psp
  OBJCOPY.OOCOutputFile: twrvf65gs10_a5.bin
  ILINK.IlinkOutputFile: timing.out
  ILINK.IlinkIcfFile: ../../../../../../../lib/twrvf65gs10_a5.iar/debug/bsp/ddr.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../lib/twrvf65gs10_a5.iar/debug/bsp/bsp.a; ../../../../../../../lib/twrvf65gs10_a5.iar/debug/psp/psp.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration ddr release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1
  ICCARM.CCIncludePath2: ../../..; ../../../../../../source/include; ../../../../../../../lib/twrvf65gs10_a5.iar/release/bsp/Generated_Code; ../../../../../../../lib/twrvf65gs10_a5.iar/release; ../../../../../../../lib/twrvf65gs10_a5.iar/release/bsp; ../../../../../../../lib/twrvf65gs10_a5.iar/release/psp
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG=1
  AARM.AUserIncludes: ../../../../../../../lib/twrvf65gs10_a5.iar/release/bsp/Generated_Code; ../../../../../../../lib/twrvf65gs10_a5.iar/release; ../../../../../../../lib/twrvf65gs10_a5.iar/release/bsp; ../../../../../../../lib/twrvf65gs10_a5.iar/release/psp
  ILINK.IlinkIcfFile: ../../../../../../../lib/twrvf65gs10_a5.iar/release/bsp/ddr.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../lib/twrvf65gs10_a5.iar/release/bsp/bsp.a; ../../../../../../../lib/twrvf65gs10_a5.iar/release/psp/psp.a
configuration int ram debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ../../../../../../../lib/twrvf65gs10_a5.iar/debug/bsp/intram.icf
configuration int ram release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG=1
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../../lib/twrvf65gs10_a5.iar/release/bsp/intram.icf
  ILINK.IlinkAdditionalLibs: as above
  group Sources
    ../../../: test.c test.h config.h
