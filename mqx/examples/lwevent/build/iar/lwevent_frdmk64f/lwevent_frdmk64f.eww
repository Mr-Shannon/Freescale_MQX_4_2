<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>bsp_frdmk64f</project><configuration>debug</configuration></member><member><project>psp_frdmk64f</project><configuration>debug</configuration></member><member><project>lwevent_frdmk64f</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>bsp_frdmk64f</project><configuration>release</configuration></member><member><project>psp_frdmk64f</project><configuration>release</configuration></member><member><project>lwevent_frdmk64f</project><configuration>int flash release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\..\..\build\iar\bsp_frdmk64f\bsp_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\build\iar\psp_frdmk64f\psp_frdmk64f.ewp</path></project><project><path>$WS_DIR$\lwevent_frdmk64f.ewp</path></project></workspace>
