<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>bsp_kwikstikk40x256</project><configuration>debug</configuration></member><member><project>psp_kwikstikk40x256</project><configuration>debug</configuration></member><member><project>ipc_serial_cpu1_kwikstikk40x256</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>bsp_kwikstikk40x256</project><configuration>release</configuration></member><member><project>psp_kwikstikk40x256</project><configuration>release</configuration></member><member><project>ipc_serial_cpu1_kwikstikk40x256</project><configuration>int flash release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\..\..\..\build\iar\bsp_kwikstikk40x256\bsp_kwikstikk40x256.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\build\iar\psp_kwikstikk40x256\psp_kwikstikk40x256.ewp</path></project><project><path>$WS_DIR$\ipc_serial_cpu1_kwikstikk40x256.ewp</path></project></workspace>
