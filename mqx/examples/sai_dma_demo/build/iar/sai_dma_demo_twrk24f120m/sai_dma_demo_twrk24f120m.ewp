# IAR project sai_dma_demo_twrk24f120m.ewp, settings and files
configuration int flash debug (ARM, debug)
  General.OGChipSelectEditMenu: MK24FN1M0xxx12 Freescale MK24FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../..; ../../../../../../lib/twrk24f120m.iar/debug/bsp/Generated_Code; ../../../../../../lib/twrk24f120m.iar/debug; ../../../../../../lib/twrk24f120m.iar/debug/bsp; ../../../../../../lib/twrk24f120m.iar/debug/psp; ../../../../../../lib/twrk24f120m.iar/debug/mfs; ../../../../../../lib/twrk24f120m.iar/debug/shell
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: ../../../../../../lib/twrk24f120m.iar/debug/bsp/Generated_Code; ../../../../../../lib/twrk24f120m.iar/debug; ../../../../../../lib/twrk24f120m.iar/debug/bsp; ../../../../../../lib/twrk24f120m.iar/debug/psp; ../../../../../../lib/twrk24f120m.iar/debug/mfs; ../../../../../../lib/twrk24f120m.iar/debug/shell
  ILINK.IlinkOutputFile: sai_dma_demo.out
  ILINK.IlinkIcfFile: ../../../../../../lib/twrk24f120m.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/twrk24f120m.iar/debug/bsp/bsp.a; ../../../../../../lib/twrk24f120m.iar/debug/psp/psp.a; ../../../../../../lib/twrk24f120m.iar/debug/mfs/mfs.a; ../../../../../../lib/twrk24f120m.iar/debug/shell/shell.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration int flash release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1
  ICCARM.CCIncludePath2: ../../..; ../../../../../../lib/twrk24f120m.iar/release/bsp/Generated_Code; ../../../../../../lib/twrk24f120m.iar/release; ../../../../../../lib/twrk24f120m.iar/release/bsp; ../../../../../../lib/twrk24f120m.iar/release/psp; ../../../../../../lib/twrk24f120m.iar/release/mfs; ../../../../../../lib/twrk24f120m.iar/release/shell
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG=1
  AARM.AUserIncludes: ../../../../../../lib/twrk24f120m.iar/release/bsp/Generated_Code; ../../../../../../lib/twrk24f120m.iar/release; ../../../../../../lib/twrk24f120m.iar/release/bsp; ../../../../../../lib/twrk24f120m.iar/release/psp; ../../../../../../lib/twrk24f120m.iar/release/mfs; ../../../../../../lib/twrk24f120m.iar/release/shell
  ILINK.IlinkIcfFile: ../../../../../../lib/twrk24f120m.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/twrk24f120m.iar/release/bsp/bsp.a; ../../../../../../lib/twrk24f120m.iar/release/psp/psp.a; ../../../../../../lib/twrk24f120m.iar/release/mfs/mfs.a; ../../../../../../lib/twrk24f120m.iar/release/shell/shell.a
  group Sources
    ../../../: log_messages.c log_messages.h main.c main.h sgtl5000.c sgtl5000.h sh_audio.c sh_audio.h wav.c wav.h
