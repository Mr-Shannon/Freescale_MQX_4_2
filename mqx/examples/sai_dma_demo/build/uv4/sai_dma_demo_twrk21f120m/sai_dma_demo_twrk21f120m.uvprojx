# Keil uVision project sai_dma_demo_twrk21f120m.uvprojx, settings and files
target int flash debug (ARM-ADS)
  device: MK21FN1M0xxx12 Freescale Semiconductor
  cpu: CPUTYPE("Cortex-M4.fp")
  output: sai_dma_demo.axf +hex
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: -J../../.. 
-J../../../../../../lib/twrk21f120m.uv4/debug/bsp/Generated_Code 
-J../../../../../../lib/twrk21f120m.uv4/debug 
-J../../../../../../lib/twrk21f120m.uv4/debug/bsp 
-J../../../../../../lib/twrk21f120m.uv4/debug/psp 
-J../../../../../../lib/twrk21f120m.uv4/debug/mfs 
-J../../../../../../lib/twrk21f120m.uv4/debug/shell 
-J#J 
--library_interface=none 
--library_type=standardlib 
--c99 
--diag_suppress=1296,186
  c include: ../../..;../../../../../../lib/twrk21f120m.uv4/debug/bsp/Generated_Code;../../../../../../lib/twrk21f120m.uv4/debug;../../../../../../lib/twrk21f120m.uv4/debug/bsp;../../../../../../lib/twrk21f120m.uv4/debug/psp;../../../../../../lib/twrk21f120m.uv4/debug/mfs;../../../../../../lib/twrk21f120m.uv4/debug/shell
  asm misc: --cpreproc_opts '-D_DEBUG=1' --cpreproc
  asm include: ../../../../../../lib/twrk21f120m.uv4/debug/bsp/Generated_Code;../../../../../../lib/twrk21f120m.uv4/debug;../../../../../../lib/twrk21f120m.uv4/debug/bsp;../../../../../../lib/twrk21f120m.uv4/debug/psp;../../../../../../lib/twrk21f120m.uv4/debug/mfs;../../../../../../lib/twrk21f120m.uv4/debug/shell
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../../../lib/twrk21f120m.uv4/debug/bsp/intflash.scf
  link misc: ../../../../../../lib/twrk21f120m.uv4/debug/bsp/bsp.lib 
../../../../../../lib/twrk21f120m.uv4/debug/psp/psp.lib 
../../../../../../lib/twrk21f120m.uv4/debug/mfs/mfs.lib 
../../../../../../lib/twrk21f120m.uv4/debug/shell/shell.lib 
../../../../../../lib/twrk21f120m.uv4/debug/bsp/bsp.lib(vectors.o) 
../../../../../../lib/twrk21f120m.uv4/debug/psp/psp.lib(linker_symbols.o) 
--keep linker_symbols.o(KERNEL_DATA_START) 
--keep linker_symbols.o(KERNEL_DATA_END) 
--keep linker_symbols.o(BOOT_STACK) 
--keep vectors.o(.vectors_rom) 
--remove 
--autoat 
--entry 
__boot
  group Sources
    ../../../: log_messages.c log_messages.h main.c main.h sgtl5000.c sgtl5000.h sh_audio.c sh_audio.h wav.c wav.h
target int flash release (ARM-ADS)
  device: MK21FN1M0xxx12 Freescale Semiconductor
  cpu: CPUTYPE("Cortex-M4.fp")
  output: sai_dma_demo.axf +hex
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG=1
  c misc: -J../../.. 
-J../../../../../../lib/twrk21f120m.uv4/release/bsp/Generated_Code 
-J../../../../../../lib/twrk21f120m.uv4/release 
-J../../../../../../lib/twrk21f120m.uv4/release/bsp 
-J../../../../../../lib/twrk21f120m.uv4/release/psp 
-J../../../../../../lib/twrk21f120m.uv4/release/mfs 
-J../../../../../../lib/twrk21f120m.uv4/release/shell 
-J#J 
--library_interface=none 
--library_type=standardlib 
--c99 
--diag_suppress=1296,186
  c include: ../../..;../../../../../../lib/twrk21f120m.uv4/release/bsp/Generated_Code;../../../../../../lib/twrk21f120m.uv4/release;../../../../../../lib/twrk21f120m.uv4/release/bsp;../../../../../../lib/twrk21f120m.uv4/release/psp;../../../../../../lib/twrk21f120m.uv4/release/mfs;../../../../../../lib/twrk21f120m.uv4/release/shell
  asm misc: --cpreproc_opts '-DNDEBUG=1' --cpreproc
  asm include: ../../../../../../lib/twrk21f120m.uv4/release/bsp/Generated_Code;../../../../../../lib/twrk21f120m.uv4/release;../../../../../../lib/twrk21f120m.uv4/release/bsp;../../../../../../lib/twrk21f120m.uv4/release/psp;../../../../../../lib/twrk21f120m.uv4/release/mfs;../../../../../../lib/twrk21f120m.uv4/release/shell
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../../../lib/twrk21f120m.uv4/release/bsp/intflash.scf
  link misc: ../../../../../../lib/twrk21f120m.uv4/release/bsp/bsp.lib 
../../../../../../lib/twrk21f120m.uv4/release/psp/psp.lib 
../../../../../../lib/twrk21f120m.uv4/release/mfs/mfs.lib 
../../../../../../lib/twrk21f120m.uv4/release/shell/shell.lib 
../../../../../../lib/twrk21f120m.uv4/release/bsp/bsp.lib(vectors.o) 
../../../../../../lib/twrk21f120m.uv4/release/psp/psp.lib(linker_symbols.o) 
--keep linker_symbols.o(KERNEL_DATA_START) 
--keep linker_symbols.o(KERNEL_DATA_END) 
--keep linker_symbols.o(BOOT_STACK) 
--keep vectors.o(.vectors_rom) 
--remove 
--autoat 
--entry 
__boot
