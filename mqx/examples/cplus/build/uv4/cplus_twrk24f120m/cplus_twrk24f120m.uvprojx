# Keil uVision project cplus_twrk24f120m.uvprojx, settings and files
target int flash debug (ARM-ADS)
  device: MK24FN256xxx12 Freescale
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: cplus.axf +hex
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: -J../../../../../../lib/twrk24f120m.uv4/debug/bsp/Generated_Code 
-J../../../../../../lib/twrk24f120m.uv4/debug 
-J../../../../../../lib/twrk24f120m.uv4/debug/bsp 
-J../../../../../../lib/twrk24f120m.uv4/debug/psp 
-J#J 
--library_interface=none 
--library_type=standardlib 
--cpp 
--diag_suppress=1296,186
  c include: ../../../../../../lib/twrk24f120m.uv4/debug/bsp/Generated_Code;../../../../../../lib/twrk24f120m.uv4/debug;../../../../../../lib/twrk24f120m.uv4/debug/bsp;../../../../../../lib/twrk24f120m.uv4/debug/psp
  asm misc: --cpreproc_opts '-D_DEBUG=1' --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../../../lib/twrk24f120m.uv4/debug/bsp/intflash.scf
  link misc: ../../../../../../lib/twrk24f120m.uv4/debug/bsp/bsp.lib 
../../../../../../lib/twrk24f120m.uv4/debug/psp/psp.lib 
../../../../../../lib/twrk24f120m.uv4/debug/bsp/bsp.lib(vectors.o) 
../../../../../../lib/twrk24f120m.uv4/debug/psp/psp.lib(linker_symbols.o) 
--keep linker_symbols.o(KERNEL_DATA_START) 
--keep linker_symbols.o(KERNEL_DATA_END) 
--keep linker_symbols.o(BOOT_STACK) 
--keep vectors.o(.vectors_rom) 
--remove 
--autoat 
--entry 
__boot
  group Sources
    ../../../: cplus.cpp
target int flash release (ARM-ADS)
  device: MK24FN256xxx12 Freescale
  cpu: as above
  output: cplus.axf +hex
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG=1
  c misc: -J../../../../../../lib/twrk24f120m.uv4/release/bsp/Generated_Code 
-J../../../../../../lib/twrk24f120m.uv4/release 
-J../../../../../../lib/twrk24f120m.uv4/release/bsp 
-J../../../../../../lib/twrk24f120m.uv4/release/psp 
-J#J 
--library_interface=none 
--library_type=standardlib 
--cpp 
--diag_suppress=1296,186
  c include: ../../../../../../lib/twrk24f120m.uv4/release/bsp/Generated_Code;../../../../../../lib/twrk24f120m.uv4/release;../../../../../../lib/twrk24f120m.uv4/release/bsp;../../../../../../lib/twrk24f120m.uv4/release/psp
  asm misc: --cpreproc_opts '-DNDEBUG=1' --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../../../lib/twrk24f120m.uv4/release/bsp/intflash.scf
  link misc: ../../../../../../lib/twrk24f120m.uv4/release/bsp/bsp.lib 
../../../../../../lib/twrk24f120m.uv4/release/psp/psp.lib 
../../../../../../lib/twrk24f120m.uv4/release/bsp/bsp.lib(vectors.o) 
../../../../../../lib/twrk24f120m.uv4/release/psp/psp.lib(linker_symbols.o) 
--keep linker_symbols.o(KERNEL_DATA_START) 
--keep linker_symbols.o(KERNEL_DATA_END) 
--keep linker_symbols.o(BOOT_STACK) 
--keep vectors.o(.vectors_rom) 
--remove 
--autoat 
--entry 
__boot
