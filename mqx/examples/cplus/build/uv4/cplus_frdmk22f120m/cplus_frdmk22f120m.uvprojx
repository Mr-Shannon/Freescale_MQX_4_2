# Keil uVision project cplus_frdmk22f120m.uvprojx, settings and files
target int flash debug (ARM-ADS)
  device: MK22DN512xxx5 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: cplus.axf +hex
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: -J../../../../../../lib/frdmk22f120m.uv4/debug/bsp/Generated_Code 
-J../../../../../../lib/frdmk22f120m.uv4/debug 
-J../../../../../../lib/frdmk22f120m.uv4/debug/bsp 
-J../../../../../../lib/frdmk22f120m.uv4/debug/psp 
-J#J 
--library_interface=none 
--library_type=standardlib 
--cpp 
--diag_suppress=1296,186
  c include: ../../../../../../lib/frdmk22f120m.uv4/debug/bsp/Generated_Code;../../../../../../lib/frdmk22f120m.uv4/debug;../../../../../../lib/frdmk22f120m.uv4/debug/bsp;../../../../../../lib/frdmk22f120m.uv4/debug/psp
  asm misc: --cpreproc_opts '-D_DEBUG=1' --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../../../lib/frdmk22f120m.uv4/debug/bsp/intflash.scf
  link misc: ../../../../../../lib/frdmk22f120m.uv4/debug/bsp/bsp.lib 
../../../../../../lib/frdmk22f120m.uv4/debug/psp/psp.lib 
../../../../../../lib/frdmk22f120m.uv4/debug/bsp/bsp.lib(vectors.o) 
../../../../../../lib/frdmk22f120m.uv4/debug/psp/psp.lib(linker_symbols.o) 
--keep linker_symbols.o(KERNEL_DATA_START) 
--keep linker_symbols.o(KERNEL_DATA_END) 
--keep linker_symbols.o(BOOT_STACK) 
--keep vectors.o(.vectors_rom) 
--remove 
--autoat 
--entry 
__boot
  group Sources
    ../../../: cplus.cpp
target int flash release (ARM-ADS)
  device: MK22DN512xxx5 Freescale Semiconductor
  cpu: as above
  output: cplus.axf +hex
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG=1
  c misc: -J../../../../../../lib/frdmk22f120m.uv4/release/bsp/Generated_Code 
-J../../../../../../lib/frdmk22f120m.uv4/release 
-J../../../../../../lib/frdmk22f120m.uv4/release/bsp 
-J../../../../../../lib/frdmk22f120m.uv4/release/psp 
-J#J 
--library_interface=none 
--library_type=standardlib 
--cpp 
--diag_suppress=1296,186
  c include: ../../../../../../lib/frdmk22f120m.uv4/release/bsp/Generated_Code;../../../../../../lib/frdmk22f120m.uv4/release;../../../../../../lib/frdmk22f120m.uv4/release/bsp;../../../../../../lib/frdmk22f120m.uv4/release/psp
  asm misc: --cpreproc_opts '-DNDEBUG=1' --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../../../lib/frdmk22f120m.uv4/release/bsp/intflash.scf
  link misc: ../../../../../../lib/frdmk22f120m.uv4/release/bsp/bsp.lib 
../../../../../../lib/frdmk22f120m.uv4/release/psp/psp.lib 
../../../../../../lib/frdmk22f120m.uv4/release/bsp/bsp.lib(vectors.o) 
../../../../../../lib/frdmk22f120m.uv4/release/psp/psp.lib(linker_symbols.o) 
--keep linker_symbols.o(KERNEL_DATA_START) 
--keep linker_symbols.o(KERNEL_DATA_END) 
--keep linker_symbols.o(BOOT_STACK) 
--keep vectors.o(.vectors_rom) 
--remove 
--autoat 
--entry 
__boot
