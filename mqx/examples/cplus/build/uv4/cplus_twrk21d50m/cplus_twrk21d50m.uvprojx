# Keil uVision project cplus_twrk21d50m.uvprojx, settings and files
target int flash debug (ARM-ADS)
  device: MK20DN512xxx10 Freescale Semiconductor
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20001FFF) IROM(0x0-0x1FFFF) IROM2(0x10000000-0x10007FFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: cplus.axf +hex
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: -J../../../../../../lib/twrk21d50m.uv4/debug/bsp/Generated_Code 
-J../../../../../../lib/twrk21d50m.uv4/debug 
-J../../../../../../lib/twrk21d50m.uv4/debug/bsp 
-J../../../../../../lib/twrk21d50m.uv4/debug/psp 
-J#J 
--library_interface=none 
--library_type=standardlib 
--cpp 
--diag_suppress=1296,186
  c include: ../../../../../../lib/twrk21d50m.uv4/debug/bsp/Generated_Code;../../../../../../lib/twrk21d50m.uv4/debug;../../../../../../lib/twrk21d50m.uv4/debug/bsp;../../../../../../lib/twrk21d50m.uv4/debug/psp
  asm misc: --cpreproc_opts '-D_DEBUG=1' --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x08000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ../../../../../../lib/twrk21d50m.uv4/debug/bsp/intflash.scf
  link misc: ../../../../../../lib/twrk21d50m.uv4/debug/bsp/bsp.lib 
../../../../../../lib/twrk21d50m.uv4/debug/psp/psp.lib 
../../../../../../lib/twrk21d50m.uv4/debug/bsp/bsp.lib(vectors.o) 
../../../../../../lib/twrk21d50m.uv4/debug/psp/psp.lib(linker_symbols.o) 
--keep linker_symbols.o(KERNEL_DATA_START) 
--keep linker_symbols.o(KERNEL_DATA_END) 
--keep linker_symbols.o(BOOT_STACK) 
--keep vectors.o(.vectors_rom) 
--remove 
--autoat 
--entry 
__boot
  group Sources
    ../../../: cplus.cpp
target int flash release (ARM-ADS)
  device: MK20DN512xxx10 Freescale Semiconductor
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20001FFF) IROM(0x0-0x1FFFF) IROM2(0x10000000-0x10007FFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: cplus.axf +hex
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG=1
  c misc: -J../../../../../../lib/twrk21d50m.uv4/release/bsp/Generated_Code 
-J../../../../../../lib/twrk21d50m.uv4/release 
-J../../../../../../lib/twrk21d50m.uv4/release/bsp 
-J../../../../../../lib/twrk21d50m.uv4/release/psp 
-J#J 
--library_interface=none 
--library_type=standardlib 
--cpp 
--diag_suppress=1296,186
  c include: ../../../../../../lib/twrk21d50m.uv4/release/bsp/Generated_Code;../../../../../../lib/twrk21d50m.uv4/release;../../../../../../lib/twrk21d50m.uv4/release/bsp;../../../../../../lib/twrk21d50m.uv4/release/psp
  asm misc: --cpreproc_opts '-DNDEBUG=1' --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x08000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: ../../../../../../lib/twrk21d50m.uv4/release/bsp/intflash.scf
  link misc: ../../../../../../lib/twrk21d50m.uv4/release/bsp/bsp.lib 
../../../../../../lib/twrk21d50m.uv4/release/psp/psp.lib 
../../../../../../lib/twrk21d50m.uv4/release/bsp/bsp.lib(vectors.o) 
../../../../../../lib/twrk21d50m.uv4/release/psp/psp.lib(linker_symbols.o) 
--keep linker_symbols.o(KERNEL_DATA_START) 
--keep linker_symbols.o(KERNEL_DATA_END) 
--keep linker_symbols.o(BOOT_STACK) 
--keep vectors.o(.vectors_rom) 
--remove 
--autoat 
--entry 
__boot
