# Keil uVision project bsp_twrk70f120m.uvprojx, settings and files
target debug (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: CPUTYPE("Cortex-M4.fp")
  output: bsp.lib (library)
  AfterMake: ../../bat/bsp_twrk70f120m.bat ../../../.. ../../../../lib/twrk70f120m.uv4/debug/bsp uv4
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: -J../../../source/io/adc/kadc 
-J../../../source/io/adc 
-J../../../source/io/cm 
-J../../../../config/twrk70f120m 
-J../../../source/io/dma 
-J../../../source/io/enet/macnet 
-J../../../source/io/enet/phy 
-J../../../source/io/enet 
-J../../../source/io/esdhc 
-J../../../source/io/flashx/freescale 
-J../../../source/io/flashx 
-J../../../source/io/flashx/amd 
-J../../../source/io/flashx/fujitsu 
-J../../../source/io/flashx/spansion 
-J../../../source/io/flashx/atmel 
-J../../../source/io/flashx/istrata 
-J../../../source/io/flashx/sharp 
-J../../../source/io/can/flexcan 
-J../../../source/io/gpio/kgpio 
-J../../../source/io/gpio 
-J../../../source/io/hmi 
-J../../../source/io/hmi/TSS/shared 
-J../../../source/io/hwtimer 
-J../../../source/io/i2c 
-J../../../source/io/i2c/polled 
-J../../../source/io/i2c/int 
-J../../../source/bsp/twrk70f120m 
-J../../../../config/common 
-J../../../source/include 
-J../../../source/bsp/twrk70f120m 
-J../../../source/io/enet 
-J../../../source/io/debug 
-J../../../source/io/io_mem 
-J../../../source/io/io_null 
-J../../../source/io/pipe 
-J../../../source/io/lpm 
-J../../../source/io/lwadc 
-J../../../source/io/lwgpio 
-J../../../source/io/nandflash/nfc 
-J../../../source/io/nandflash 
-J../../../source/io/pcb 
-J../../../source/io/pcb/mqxa 
-J../../../source/io/pccard 
-J../../../source/io/pcflash 
-J../../../source/io/rtc 
-J../../../source/io/sai 
-J../../../source/io/sai/dma 
-J../../../source/io/sdcard/sdcard_spi 
-J../../../source/io/sdcard/sdcard_esdhc 
-J../../../source/io/sdcard 
-J../../../source/io/serial 
-J../../../source/io/spi 
-J../../../source/io/tchres 
-J../../../source/io/tfs 
-J../../../source/io/timer 
-J../../../source/io/usb 
-J../../../source/psp/cortex_m/compiler/rv_uv4 
-J../../../source/psp/cortex_m/cpu 
-J../../../source/psp/cortex_m 
-J../../../../config/twrk70f120m 
-J../../../../config/common 
-J../../../source/include 
-J../../../source/tad 
-J#J 
--library_interface=none 
--library_type=standardlib 
--c99 
--diag_suppress=1296,186
  c include: ../../../source/io/adc/kadc;../../../source/io/adc;../../../source/io/cm;../../../../config/twrk70f120m;../../../source/io/dma;../../../source/io/enet/macnet;../../../source/io/enet/phy;../../../source/io/enet;../../../source/io/esdhc;../../../source/io/flashx/freescale;../../../source/io/flashx;../../../source/io/flashx/amd;../../../source/io/flashx/fujitsu;../../../source/io/flashx/spansion;../../../source/io/flashx/atmel;../../../source/io/flashx/istrata;../../../source/io/flashx/sharp;../../../source/io/can/flexcan;../../../source/io/gpio/kgpio;../../../source/io/gpio;../../../source/io/hmi;../../../source/io/hmi/TSS/shared;../../../source/io/hwtimer;../../../source/io/i2c;../../../source/io/i2c/polled;../../../source/io/i2c/int;../../../source/bsp/twrk70f120m;../../../../config/common;../../../source/include;../../../source/bsp/twrk70f120m;../../../source/io/enet;../../../source/io/debug;../../../source/io/io_mem;../../../source/io/io_null;../../../source/io/pipe;../../../source/io/lpm;../../../source/io/lwadc;../../../source/io/lwgpio;../../../source/io/nandflash/nfc;../../../source/io/nandflash;../../../source/io/pcb;../../../source/io/pcb/mqxa;../../../source/io/pccard;../../../source/io/pcflash;../../../source/io/rtc;../../../source/io/sai;../../../source/io/sai/dma;../../../source/io/sdcard/sdcard_spi;../../../source/io/sdcard/sdcard_esdhc;../../../source/io/sdcard;../../../source/io/serial;../../../source/io/spi;../../../source/io/tchres;../../../source/io/tfs;../../../source/io/timer;../../../source/io/usb;../../../source/psp/cortex_m/compiler/rv_uv4;../../../source/psp/cortex_m/cpu;../../../source/psp/cortex_m;../../../../config/twrk70f120m;../../../../config/common;../../../source/include;../../../source/tad
  asm misc: --cpreproc_opts '-D_DEBUG=1' --cpreproc
  asm include: ../../../source/io/debug;../../../source/psp/cortex_m/compiler/rv_uv4;../../../source/psp/cortex_m;../../../source/psp/cortex_m/core/M4;../../../../config/twrk70f120m;../../../source/include;../../../../config/common
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk70f120m.uv4\mqx\intflash.scf
  group Peripheral IO Drivers/adc
    ../../../source/io/adc/kadc/: adc_mk70.c adc_mk70.h
    ../../../source/io/adc/: adc.h adc.c adc_conf.h adc_prv.h
  group Peripheral IO Drivers/adc/kadc
    ../../../source/io/adc/kadc/: adc_kadc.c adc_kadc.h adc_kadc_prv.h adt_kpdb.c
  group Generic IO Drivers/cm
    ../../../source/io/cm/: cm_kinetis.h cm.h cm.c
  group User Config
    ../../../../config/twrk70f120m/: user_config.h
  group Peripheral IO Drivers/dma
    ../../../source/io/dma/: edma_kinetisf.c dma.c dma.h edma.c edma.h edma_prv.h
  group Peripheral IO Drivers/enet
    ../../../source/io/enet/macnet/: macnet_mk70.c macnet_mk70.h
    ../../../source/io/enet/: enet_rev.h enetprv.h enaddr.c enclose.c enerr.c eninit.c enjoin.c enleave.c enmediactl.c enopen.c enrecv.c ensend.c enstat.c enstop.c enutil.c
  group Peripheral IO Drivers/enet/phy
    ../../../source/io/enet/phy/: phy_ksz8041.c phy_ksz8041.h
  group Peripheral IO Drivers/enet/macnet
    ../../../source/io/enet/macnet/: macnet_init.c macnet_join.c macnet_mii.c macnet_prv.h macnet_receive.c macnet_rejoin.c macnet_rev.h macnet_send.c macnet_stop.c macnet_util.c macnet_1588.c macnet_1588.h
  group Peripheral IO Drivers/esdhc
    ../../../source/io/esdhc/: esdhc_mk70.c esdhc.h esdhc.c esdhc_prv.h
  group Peripheral IO Drivers/flashx
    ../../../source/io/flashx/freescale/: flash_mk70.c flash_mk70.h
    ../../../source/io/flashx/: flashx.c flashx.h flashxprv.h
  group Peripheral IO Drivers/flashx/freescale
    ../../../source/io/flashx/freescale/: flash_ftfe.c flash_ftfe.h flash_ftfe_prv.h
  group Peripheral IO Drivers/flexcan
    ../../../source/io/can/flexcan/: fsl_flexcan_hal.c fsl_flexcan_hal.h fsl_flexcan_driver.c fsl_flexcan_driver.h fsl_flexcan_int.c fsl_flexcan_int.h
  group Peripheral IO Drivers/gpio/knxx
    ../../../source/io/gpio/kgpio/: io_gpio_kgpio.c io_gpio_kgpio.h io_gpio_kgpio_prv.h
  group Peripheral IO Drivers/gpio
    ../../../source/io/gpio/: io_gpio.h io_gpio.c io_gpio_prv.h
  group Generic IO Drivers/hmi
    ../../../source/io/hmi/: btnled.h btnled.c derivative.h hmi_client.c hmi_client.h hmi_lwgpio_provider.c hmi_lwgpio_provider.h hmi_tss_provider.c hmi_tss_provider.h hmi_uids.h hmi_provider.h
  group Generic IO Drivers/hmi/tss
    ../../../source/io/hmi/TSS/shared/: TSS_API.h TSS_DataTypes.h TSS_Freemaster.c TSS_GPIO.h TSS_Sensor.c TSS_Sensor.h TSS_SensorGPIO.c TSS_SensorGPIO.h TSS_SensorGPIO_def.h TSS_SensorTSI.c TSS_SensorTSI.h TSS_SensorTSI_def.h TSS_SensorTSIL.c TSS_SensorTSIL.h TSS_SensorTSIL_def.h TSS_StatusCodes.h TSS_SystemSetupData.c TSS_SystemSetupVal.h TSS_Timer.h
  group Peripheral IO Drivers/hwtimer
    ../../../source/io/hwtimer/: hwtimer_lpt.c hwtimer_lpt.h hwtimer_systick.c hwtimer_systick.h hwtimer_pit.c hwtimer_pit.h hwtimer_kinetis.c hwtimer.c hwtimer.h
  group Peripheral IO Drivers/i2c
    ../../../source/io/i2c/: i2c_mk70.c i2c_ki2c.h i2c_ki2c_prv.h i2c.h
    ../../../source/io/i2c/polled/: i2c_pol_ki2c.c
    ../../../source/io/i2c/int/: i2c_int_ki2c_legacy.c
  group Peripheral IO Drivers/i2c/polled
    ../../../source/io/i2c/polled/: i2c_pol_prv.h i2c_pol.c
  group Peripheral IO Drivers/i2c/int
    ../../../source/io/i2c/int/: i2c_int_prv.h i2c_int.c
  group BSP Files
    ../../../source/bsp/twrk70f120m/: bsp_cm.h bsp_cm.c init_adc.c init_lwadc.c init_enet.c init_esdhc.c init_gpio.c init_hw.c TSS_SystemSetup.h init_hmi.c init_i2c.c init_lpm.h init_lpm.c init_nandflash.c init_sai.c init_sci.c init_sdcard.c init_spi.c init_iodebug.c init_flashx.c init_cfcard.c init_usb.c init_dma.c bsp.h bsp_prv.h bsp_rev.h init_bsp.c mqx_init.c mqx_main.c PE_LDD.h PE_Types.h twrk70f120m.h vectors.c
    ../../../../config/common/: small_ram_config.h smallest_config.h maximum_config.h verif_enabled_config.h
    ../../../source/include/: mqx.h
    ../../../source/io/enet/: ethernet.h enet.h enet_wifi.h
  group Generic IO Drivers/debug
    ../../../source/io/debug/: iodebug.h iodebug_prv.h iodebug.c iodebug_asm.S
  group Generic IO Drivers/io_mem
    ../../../source/io/io_mem/: io_mem.c io_mem.h iomemprv.h
  group Generic IO Drivers/io_null
    ../../../source/io/io_null/: io_null.c io_null.h ionulprv.h
  group Generic IO Drivers/iopipe
    ../../../source/io/pipe/: io_pipe.c io_pipe.h pipe_prv.h
  group Generic IO Drivers/lpm
    ../../../source/io/lpm/: lpm_kinetis.h lpm_smc.c lpm.h lpm_prv.h lpm.c
  group Peripheral IO Drivers/lwadc
    ../../../source/io/lwadc/: lwadc_k70.c lwadc.h
  group Peripheral IO Drivers/lwadc/kadc
    ../../../source/io/lwadc/: lwadc_kadc.c lwadc_kadc.h lwadc_kadc_prv.h
  group Peripheral IO Drivers/lwgpio/kgpio
    ../../../source/io/lwgpio/: lwgpio_kgpio.c lwgpio_kgpio.h
  group Peripheral IO Drivers/lwgpio
    ../../../source/io/lwgpio/: lwgpio.h lwgpio.c
  group Peripheral IO Drivers/nandflash
    ../../../source/io/nandflash/nfc/: nfc_k70f120m.c nfc.c nfc.h nfc_dma.c nfc_dma.h
    ../../../source/io/nandflash/nand_devices/: MT29F2G16.c
    ../../../source/io/nandflash/: nandflash.c nandflash.h nandflashprv.h
  group Generic IO Drivers/pcb
    ../../../source/io/pcb/: io_pcb2.c io_pcb.c io_pcb.h iopcbprv.h
    ../../../source/io/pcb/mqxa/: pcb_mqxa.c pcb_mqxa.h pcbmqxav.h
  group Peripheral IO Drivers/pccard
    ../../../source/io/pccard/: pccardflexbus.h pccardflexbuspr.h pccardflexbus.c apccard.h
  group Peripheral IO Drivers/pcflash
    ../../../source/io/pcflash/: pcflash.h apcflash.c apcflshpr.h ata.h
  group Peripheral IO Drivers/rtc
    ../../../source/io/rtc/: krtc.h krtc.c rtc.h
  group Peripheral IO Drivers/sai
    ../../../source/io/sai/: sai_mk70.c sai_ksai.h sai_ksai_prv.h sai.h sai_audio.h
  group Peripheral IO Drivers/sai/dma
    ../../../source/io/sai/dma/: sai_dma_ksai.c sai_dma.c sai_dma_prv.h
  group Peripheral IO Drivers/sdcard/sdcard_spi
    ../../../source/io/sdcard/sdcard_spi/: sdcard_spi.c sdcard_spi.h
  group Peripheral IO Drivers/sdcard/sdcard_esdhc
    ../../../source/io/sdcard/sdcard_esdhc/: sdcard_esdhc.c sdcard_esdhc.h
  group Peripheral IO Drivers/sdcard
    ../../../source/io/sdcard/: sdcard.c sdcard.h sdcard_prv.h
  group Peripheral IO Drivers/serial
    ../../../source/io/serial/: serl_mk70.c serl_kuart.h io_sinit.c serial.h serinprv.h serplprv.h
  group Peripheral IO Drivers/serial/int
    ../../../source/io/serial/int/: serl_int_kuart.c serl_int.c
  group Peripheral IO Drivers/serial/polled
    ../../../source/io/serial/polled/: serl_pol_kuart.c serl_pol.c
  group Peripheral IO Drivers/serial/dma
    ../../../source/io/serial/dma/: serl_dma_kuart.c
  group Peripheral IO Drivers/spi
    ../../../source/io/spi/: spi_mk70.c spi_dspi_dma.h spi_dspi_dma.c spi_dspi_dma_prv.h spi_dspi_common.h spi_dspi_common.c spi.h spi.c spi_prv.h spi_dspi.h spi_dspi.c spi_dspi_prv.h
  group Peripheral IO Drivers/tchres
    ../../../source/io/tchres/: tchres.h tchres_prv.h tchres.c
  group Generic IO Drivers/tfs
    ../../../source/io/tfs/: tfs.c tfs.h tfs_prv.h
  group Peripheral IO Drivers/timer
    ../../../source/io/timer/: timer_qpit.c timer_kinetis.c timer_qpit.h qpit.h
  group Peripheral IO Drivers/usb
    ../../../source/io/usb/: usb_mk70f.c usb_mk70f_device.c if_host_ehci.h if_host_khci.h if_dev_ehci.h if_dev_khci.h usb_bsp.h usb_install.c
target release (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: CPUTYPE("Cortex-M4.fp")
  output: bsp.lib (library)
  AfterMake: ../../bat/bsp_twrk70f120m.bat ../../../.. ../../../../lib/twrk70f120m.uv4/release/bsp uv4
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG=1
  c misc: as above
  c include: as above
  asm misc: --cpreproc_opts '-DNDEBUG=1' --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk70f120m.uv4\mqx\intflash.scf
