# Keil uVision project psp_twrk60f120m.uvprojx, settings and files
target debug (ARM-ADS)
  device: MK60FN1M0xxx12 Freescale Semiconductor
  cpu: CPUTYPE("Cortex-M4.fp")
  output: psp.lib (library)
  AfterMake: ../../bat/psp_twrk60f120m.bat ../../../.. ../../../../lib/twrk60f120m.uv4/debug/psp uv4
  c flags: Optim=1 OneElfS=1
  c define: MQX_DISABLE_CONFIG_CHECK=1, _DEBUG=1
  c misc: -J../../../source/psp/cortex_m/compiler/rv_uv4 
-J../../../source/psp/cortex_m/cpu 
-J../../../source/psp/cortex_m 
-J../../../../config/twrk60f120m 
-J../../../../config/common 
-J../../../source/include 
-J../../../source/tad 
-J../../../source/io/adc/kadc 
-J../../../source/io/adc 
-J../../../source/io/cm 
-J../../../../config/twrk60f120m 
-J../../../source/io/dma 
-J../../../source/io/enet/macnet 
-J../../../source/io/enet/phy 
-J../../../source/io/enet 
-J../../../source/io/esdhc 
-J../../../source/io/flashx/freescale 
-J../../../source/io/flashx 
-J../../../source/io/flashx/amd 
-J../../../source/io/flashx/fujitsu 
-J../../../source/io/flashx/spansion 
-J../../../source/io/flashx/atmel 
-J../../../source/io/flashx/istrata 
-J../../../source/io/flashx/sharp 
-J../../../source/io/can/flexcan 
-J../../../source/io/gpio/kgpio 
-J../../../source/io/gpio 
-J../../../source/io/hwtimer 
-J../../../source/io/i2c 
-J../../../source/io/i2c/polled 
-J../../../source/io/i2c/int 
-J../../../source/bsp/twrk60f120m 
-J../../../../config/common 
-J../../../source/include 
-J../../../source/bsp/twrk60f120m 
-J../../../source/io/enet 
-J../../../source/io/debug 
-J../../../source/io/io_mem 
-J../../../source/io/io_null 
-J../../../source/io/pipe 
-J../../../source/io/lpm 
-J../../../source/io/lwadc 
-J../../../source/io/lwgpio 
-J../../../source/io/nandflash/nfc 
-J../../../source/io/nandflash 
-J../../../source/io/pcb 
-J../../../source/io/pcb/mqxa 
-J../../../source/io/pccard 
-J../../../source/io/pcflash 
-J../../../source/io/rtc 
-J../../../source/io/sai 
-J../../../source/io/sai/dma 
-J../../../source/io/sdcard/sdcard_esdhc 
-J../../../source/io/sdcard/sdcard_spi 
-J../../../source/io/sdcard 
-J../../../source/io/serial 
-J../../../source/io/spi 
-J../../../source/io/tchres 
-J../../../source/io/tfs 
-J../../../source/io/timer 
-J../../../source/io/usb 
-J../../../source/io/usb_dcd 
-J../../../source/io/usb_dcd/polled 
-J../../../source/io/usb_dcd/int 
-J#J 
--library_interface=none 
--library_type=standardlib 
--c99 
--diag_suppress=1296,186
  c include: ../../../source/psp/cortex_m/compiler/rv_uv4;../../../source/psp/cortex_m/cpu;../../../source/psp/cortex_m;../../../../config/twrk60f120m;../../../../config/common;../../../source/include;../../../source/tad;../../../source/io/adc/kadc;../../../source/io/adc;../../../source/io/cm;../../../../config/twrk60f120m;../../../source/io/dma;../../../source/io/enet/macnet;../../../source/io/enet/phy;../../../source/io/enet;../../../source/io/esdhc;../../../source/io/flashx/freescale;../../../source/io/flashx;../../../source/io/flashx/amd;../../../source/io/flashx/fujitsu;../../../source/io/flashx/spansion;../../../source/io/flashx/atmel;../../../source/io/flashx/istrata;../../../source/io/flashx/sharp;../../../source/io/can/flexcan;../../../source/io/gpio/kgpio;../../../source/io/gpio;../../../source/io/hwtimer;../../../source/io/i2c;../../../source/io/i2c/polled;../../../source/io/i2c/int;../../../source/bsp/twrk60f120m;../../../../config/common;../../../source/include;../../../source/bsp/twrk60f120m;../../../source/io/enet;../../../source/io/debug;../../../source/io/io_mem;../../../source/io/io_null;../../../source/io/pipe;../../../source/io/lpm;../../../source/io/lwadc;../../../source/io/lwgpio;../../../source/io/nandflash/nfc;../../../source/io/nandflash;../../../source/io/pcb;../../../source/io/pcb/mqxa;../../../source/io/pccard;../../../source/io/pcflash;../../../source/io/rtc;../../../source/io/sai;../../../source/io/sai/dma;../../../source/io/sdcard/sdcard_esdhc;../../../source/io/sdcard/sdcard_spi;../../../source/io/sdcard;../../../source/io/serial;../../../source/io/spi;../../../source/io/tchres;../../../source/io/tfs;../../../source/io/timer;../../../source/io/usb;../../../source/io/usb_dcd;../../../source/io/usb_dcd/polled;../../../source/io/usb_dcd/int
  asm misc: --cpreproc_opts '-DMQX_DISABLE_CONFIG_CHECK=1,-D_DEBUG=1' --cpreproc
  asm include: ../../../source/psp/cortex_m/compiler/rv_uv4;../../../source/psp/cortex_m;../../../source/psp/cortex_m/core/M4;../../../../config/twrk60f120m;../../../source/include;../../../../config/common;../../../source/io/debug
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk60f120m.uv4\mqx\intflash.scf
  group PSP Cortex
    ../../../source/psp/cortex_m/cpu/: MK60F12.h kinetis_fcan.h
    ../../../source/psp/cortex_m/: cache.c kinetis_mpu.h kinetis_mpu.c types.inc int_gkis.c int_inst.c int_kisr.c int_pvta.c int_unx.c int_vtab.c int_xcpt.c ipsum.c mem_copy.c mem_zero.c psp_dati.c psp_gelms.c psp_hoti.c psp_iinit.c psp_mat1.c psp_mat2.c psp_mat3.c psp_miti.c psp_msti.c psp_mstiq.c psp_nsti.c psp_psti.c psp_seti.c psp_supp.c psp_tiad.c psp_tida.c psp_tihr.c psp_timn.c psp_tims.c psp_tinm.c psp_tins.c psp_tiol.c psp_tipr.c psp_tips.c psp_tise.c psp_tisu.c psp_tius.c psp_tkti.c psp_usti.c sc_irdyq.c stack_bu.c stack_de.c stack_st.c k_assert.c psp.h mqx_assert.h psp_abi.h psp_comp.h psp_math.h psp_prv.h psp_rev.h psp_supp.h psp_time.h psptypes.h psp_cpu.h psp_cpudef.h cortex.h cortex.c nvic.c nvic.h kinetis.h
    ../../../source/psp/cortex_m/core/M4/: psp_prv.inc boot.S dispatch.S support.S
  group User Config
    ../../../../config/twrk60f120m/: user_config.h
    ../../../../config/common/: small_ram_config.h
  group PSP Generic/kernel
    ../../../source/kernel/: event.c ipc.c idletask.c inittask.c int.c lwsem.c mem.c mqx.c sched.c task.c time.c taskq.c klog.c log.c lwevent.c lwlog.c lwmem.c lwmsgq.c lwtimer.c msg.c msgq.c msgpool.c mutex.c name.c partition.c queue.c sem.c timer.c watchdog.c
  group PSP Generic/fio
    ../../../source/fio/: io_clre.c io_dopr.c io_fclos.c io_feof.c io_ferr.c io_fflsh.c io_fgetc.c io_fgetl.c io_fgets.c io_fopen.c io_fp.c io_fprt.c io_fputc.c io_fputs.c io_fscan.c io_fseek.c io_fstat.c io_ftell.c io_fung.c io_ioctl.c io_misc.c io_pntf.c io_read.c io_scanf.c io_scanl.c io_spr.c io_sscan.c io_util.c io_vpr.c io_write.c
  group PSP Generic/include
    ../../../source/include/: gen_rev.h eds.h edserial.h edserprv.h eds_prv.h event.h event_prv.h fio.h fio_prv.h fpio_prv.h charq.h io.h ioctl.h io_prv.h io_rev.h ipc.h ipcrtprv.h ipc_pcb.h ipc_pcbv.h ipc_prv.h klog.h log.h log_prv.h lwsem.h lwevent.h lwevent_prv.h lwlog.h lwlog_prv.h lwmem.h lwmem_prv.h lwmsgq.h lwmsgq_prv.h lwtimer.h lwtimer_prv.h mem_prv.h message.h mmu.h mqx.h mqx_cnfg.h mqx_cpudef.h mqx_inc.h mqx_ioc.h mqx_prv.h mqx_str.h mqx_macros.h msg_prv.h mutex.h mutex_prv.h name.h name_prv.h partition.h partition_prv.h pcb.h posix.h queue.h sem.h sem_prv.h timer.h timer_prv.h watchdog.h watchdog_prv.h
  group PSP Generic/io
    ../../../source/io/: io_init.c io_inst.c io_instx.c io_ghand.c io_shand.c io_uinst.c
  group PSP Generic/string
    ../../../source/string/: strnlen.c str_utos.c
  group PSP Generic/tad
    ../../../source/tad/: tad.c tad.h
  group PSP Generic/kernel/tlsf
    ../../../source/kernel/: tlsf.c tlsf_adaptation.c
    ../../../source/include/: tlsf.h tlsfbits.h tlsf_adaptation.h tlsf_adaptation_prv.h
  group PSP Cortex/compiler
    ../../../source/psp/cortex_m/compiler/rv_uv4/: asm_mac.h comp.h comp.c linker_symbols.S
target release (ARM-ADS)
  device: MK60FN1M0xxx12 Freescale Semiconductor
  cpu: CPUTYPE("Cortex-M4.fp")
  output: psp.lib (library)
  AfterMake: ../../bat/psp_twrk60f120m.bat ../../../.. ../../../../lib/twrk60f120m.uv4/release/psp uv4
  c flags: Optim=4 OneElfS=1
  c define: MQX_DISABLE_CONFIG_CHECK=1, NDEBUG=1
  c misc: as above
  c include: as above
  asm misc: --cpreproc_opts '-DMQX_DISABLE_CONFIG_CHECK=1,-DNDEBUG=1' --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk60f120m.uv4\mqx\intflash.scf
