# IAR project psp_svf522revb_a5.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: PSP_HAS_SUPPORT_STRUCT=1; MQX_DISABLE_CONFIG_CHECK=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../../source/psp/cortex_a/compiler/iar; ../../../source/psp/cortex_a/cpu; ../../../source/psp/cortex_a; ../../../../config/svf522revb_a5; ../../../../config/common; ../../../source/include; ../../../source/tad; ../../../source/io/asrc; ../../../source/io/cm; ../../../source/io/cm/vybrid; ../../../../config/svf522revb_a5; ../../../source/io/core_mutex; ../../../source/io/dcu4; ../../../source/io/dma; ../../../source/io/enet/macnet; ../../../source/io/enet/phy; ../../../source/io/enet; ../../../source/io/esai; ../../../source/io/esai/esai_fifo; ../../../source/io/esai/esai_vport; ../../../source/io/esdhc; ../../../source/io/fbdev; ../../../source/io/flashx/freescale; ../../../source/io/flashx; ../../../source/io/flashx/amd; ../../../source/io/flashx/fujitsu; ../../../source/io/flashx/spansion; ../../../source/io/flashx/atmel; ../../../source/io/flashx/istrata; ../../../source/io/flashx/sharp; ../../../source/io/can/flexcan; ../../../source/io/ftm; ../../../source/io/ftm/quaddec; ../../../source/io/hwtimer; ../../../source/io/i2c; ../../../source/io/i2c/polled; ../../../source/io/i2c/int; ../../../source/bsp/svf522revb_a5; ../../../../config/common; ../../../source/include; ../../../source/bsp/svf522revb_a5; ../../../source/io/enet; ../../../source/io/io_expander; ../../../source/io/io_mem; ../../../source/io/io_null; ../../../source/io/pipe; ../../../source/io/lpm/vybrid; ../../../source/io/lpm; ../../../source/io/lwadc; ../../../source/io/lwgpio; ../../../source/io/pcb/shmem; ../../../source/io/pcb; ../../../source/io/pcb/mqxa; ../../../source/io/qspi; ../../../source/io/sai; ../../../source/io/sai/dma; ../../../source/io/sdcard/sdcard_esdhc; ../../../source/io/sdcard; ../../../source/io/serial; ../../../source/io/spi; ../../../source/io/tfs; ../../../source/io/usb
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: ../../../source/psp/cortex_a/compiler/iar; ../../../source/psp/cortex_a; ../../../source/psp/cortex_a/core/A5; ../../../../config/svf522revb_a5; ../../../source/include; ../../../../config/common
  postbuild: "../../bat/psp_svf522revb_a5.bat" "../../../.." "../../../../lib/svf522revb_a5.iar/debug/psp" iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: PSP_HAS_SUPPORT_STRUCT=1; MQX_DISABLE_CONFIG_CHECK=1; NDEBUG=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: as above
  postbuild: "../../bat/psp_svf522revb_a5.bat" "../../../.." "../../../../lib/svf522revb_a5.iar/release/psp" iar
  ILINK.IlinkOutputFile: libgeneric.out
  group PSP CortexA
    ../../../source/psp/cortex_a/cpu/: SVF522R3MK4.h
    ../../../source/psp/cortex_a/: armv7a.h cache_a5.c cache.c cortexa5.c cortexa5.h vybrid.h gic.h gic.c irouter_vybrid.h irouter_vybrid.c int_gkis.c int_inst.c int_kisr.c int_pc.c int_pvta.c int_unx.c int_vtab.c int_xcpt.c ipsum.c mem_copy.c mem_zero.c mmu_cortexa5.c mmu_cortexa5.h psp_cpu.h psp_dati.c psp_gelms.c psp_hoti.c psp_iinit.c psp_mat1.c psp_mat2.c psp_mat3.c psp_miti.c psp_msti.c psp_mstiq.c psp_nsti.c psp_psti.c psp_seti.c psp_supp.c psp_tiad.c psp_tida.c psp_tihr.c psp_timn.c psp_tims.c psp_tinm.c psp_tins.c psp_tiol.c psp_tipr.c psp_tips.c psp_tise.c psp_tisu.c psp_tius.c psp_tkti.c psp_usti.c sc_irdyq.c stack_bu.c stack_de.c stack_st.c a_assert.c psp_prv.h psp_rev.h psp_abi.h psptypes.h
    ../../../source/psp/cortex_a/core/A5/: dispatch_gic.S dispatch_sch.S boot.S support.S
  group PSP CortexA/compiler
    ../../../source/psp/cortex_a/compiler/iar/: asm_mac.h comp.h comp.c kernel_symbols.S
  group User Config
    ../../../../config/svf522revb_a5/: user_config.h
    ../../../../config/common/: small_ram_config.h
  group PSP Generic/kernel
    ../../../source/kernel/: event.c ipc.c idletask.c inittask.c int.c lwsem.c mem.c mqx.c sched.c task.c time.c taskq.c klog.c log.c lwevent.c lwlog.c lwmem.c lwmsgq.c lwtimer.c msg.c msgq.c msgpool.c mutex.c name.c partition.c queue.c sem.c timer.c watchdog.c
  group PSP Generic/kernel/tlsf
    ../../../source/kernel/: tlsf.c tlsf_adaptation.c
    ../../../source/include/: tlsf.h tlsfbits.h tlsf_adaptation.h tlsf_adaptation_prv.h
  group PSP Generic/fio
    ../../../source/fio/: io_clre.c io_dopr.c io_fclos.c io_feof.c io_ferr.c io_fflsh.c io_fgetc.c io_fgetl.c io_fgets.c io_fopen.c io_fp.c io_fprt.c io_fputc.c io_fputs.c io_fscan.c io_fseek.c io_fstat.c io_ftell.c io_fung.c io_ioctl.c io_misc.c io_pntf.c io_read.c io_scanf.c io_scanl.c io_spr.c io_sscan.c io_util.c io_vpr.c io_write.c
  group PSP Generic/include
    ../../../source/include/: gen_rev.h eds.h edserial.h edserprv.h eds_prv.h event.h event_prv.h fio.h fio_prv.h fpio_prv.h charq.h io.h ioctl.h io_prv.h io_rev.h ipc.h ipcrtprv.h ipc_pcb.h ipc_pcbv.h ipc_prv.h klog.h log.h log_prv.h lwsem.h lwevent.h lwevent_prv.h lwlog.h lwlog_prv.h lwmem.h lwmem_prv.h lwmsgq.h lwmsgq_prv.h lwtimer.h lwtimer_prv.h mem_prv.h message.h mmu.h mqx.h mqx_cnfg.h mqx_cpudef.h mqx_inc.h mqx_ioc.h mqx_prv.h mqx_str.h mqx_macros.h msg_prv.h mutex.h mutex_prv.h name.h name_prv.h partition.h partition_prv.h pcb.h posix.h queue.h sem.h sem_prv.h timer.h timer_prv.h watchdog.h watchdog_prv.h
  group PSP Generic/io
    ../../../source/io/: io_init.c io_inst.c io_instx.c io_ghand.c io_shand.c io_uinst.c
  group PSP Generic/string
    ../../../source/string/: strnlen.c str_utos.c
  group PSP Generic/tad
    ../../../source/tad/: tad.c tad.h
