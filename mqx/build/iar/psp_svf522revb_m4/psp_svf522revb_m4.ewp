# IAR project psp_svf522revb_m4.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: MQX_DISABLE_CONFIG_CHECK=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../../source/psp/cortex_m/compiler/iar; ../../../source/psp/cortex_a/cpu; ../../../source/psp/cortex_m; ../../../source/psp/cortex_a; ../../../../config/svf522revb_m4; ../../../../config/common; ../../../source/include; ../../../source/tad; ../../../source/io/asrc; ../../../source/io/cm; ../../../source/io/cm/vybrid; ../../../../config/svf522revb_m4; ../../../source/io/core_mutex; ../../../source/io/dma; ../../../source/io/enet/macnet; ../../../source/io/enet/phy; ../../../source/io/enet; ../../../source/io/esai; ../../../source/io/esai/esai_fifo; ../../../source/io/esai/esai_vport; ../../../source/io/esdhc; ../../../source/io/can/flexcan; ../../../source/io/hwtimer; ../../../source/io/i2c; ../../../source/io/i2c/polled; ../../../source/io/i2c/int; ../../../source/bsp/svf522revb_m4; ../../../../config/common; ../../../source/include; ../../../source/bsp/svf522revb_m4; ../../../source/io/enet; ../../../source/io/io_expander; ../../../source/io/io_mem; ../../../source/io/io_null; ../../../source/io/pipe; ../../../source/io/lpm/vybrid; ../../../source/io/lpm; ../../../source/io/lwadc; ../../../source/io/lwgpio; ../../../source/io/pcb/shmem; ../../../source/io/pcb; ../../../source/io/pcb/mqxa; ../../../source/io/qspi; ../../../source/io/sai; ../../../source/io/sai/dma; ../../../source/io/sdcard/sdcard_esdhc; ../../../source/io/sdcard; ../../../source/io/serial; ../../../source/io/spi; ../../../source/io/tfs; ../../../source/io/usb
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: MQX_DISABLE_CONFIG_CHECK=1; _DEBUG=1
  AARM.AUserIncludes: ../../../source/psp/cortex_m/compiler/iar; ../../../source/psp/cortex_m; ../../../source/psp/cortex_m/core/M4; ../../../source/psp/cortex_a; ../../../../config/svf522revb_m4; ../../../source/include; ../../../../config/common
  postbuild: "../../bat/psp_svf522revb_m4.bat" "../../../.." "../../../../lib/svf522revb_m4.iar/debug/psp" iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: MQX_DISABLE_CONFIG_CHECK=1; NDEBUG=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: MQX_DISABLE_CONFIG_CHECK=1; NDEBUG=1
  postbuild: "../../bat/psp_svf522revb_m4.bat" "../../../.." "../../../../lib/svf522revb_m4.iar/release/psp" iar
  ILINK.IlinkOutputFile: libgeneric.out
  group PSP Cortex
    ../../../source/psp/cortex_a/cpu/: SVF522R3MK4.h
    ../../../source/psp/cortex_m/: types.inc cache.c int_gkis.c int_inst.c int_kisr.c int_pvta.c int_unx.c int_vtab.c int_xcpt.c ipsum.c mem_copy.c mem_zero.c psp_dati.c psp_gelms.c psp_hoti.c psp_iinit.c psp_mat1.c psp_mat2.c psp_mat3.c psp_miti.c psp_msti.c psp_mstiq.c psp_nsti.c psp_psti.c psp_seti.c psp_supp.c psp_tiad.c psp_tida.c psp_tihr.c psp_timn.c psp_tims.c psp_tinm.c psp_tins.c psp_tiol.c psp_tipr.c psp_tips.c psp_tise.c psp_tisu.c psp_tius.c psp_tkti.c psp_usti.c sc_irdyq.c stack_bu.c stack_de.c stack_st.c k_assert.c psp.h mqx_assert.h psp_abi.h psp_comp.h psp_math.h psp_prv.h psp_rev.h psp_supp.h psp_time.h psptypes.h psp_cpu.h psp_cpudef.h cortex.h cortex.c nvic.c nvic.h
    ../../../source/psp/cortex_m/core/M4/: psp_prv.inc boot.S dispatch.S support.S
    ../../../source/psp/cortex_a/: irouter_vybrid.h irouter_vybrid.c vybrid.h
  group PSP Cortex/compiler
    ../../../source/psp/cortex_m/compiler/iar/: asm_mac.h comp.h comp.c kernel_symbols.S
  group User Config
    ../../../../config/svf522revb_m4/: user_config.h
    ../../../../config/common/: small_ram_config.h
  group PSP Generic/kernel
    ../../../source/kernel/: event.c ipc.c idletask.c inittask.c int.c lwsem.c mem.c mqx.c sched.c task.c time.c taskq.c klog.c log.c lwevent.c lwlog.c lwmem.c lwmsgq.c lwtimer.c msg.c msgq.c msgpool.c mutex.c name.c partition.c queue.c sem.c timer.c watchdog.c
  group PSP Generic/kernel/tlsf
    ../../../source/kernel/: tlsf.c tlsf_adaptation.c
    ../../../source/include/: tlsf.h tlsfbits.h tlsf_adaptation.h tlsf_adaptation_prv.h
  group PSP Generic/fio
    ../../../source/fio/: io_clre.c io_dopr.c io_fclos.c io_feof.c io_ferr.c io_fflsh.c io_fgetc.c io_fgetl.c io_fgets.c io_fopen.c io_fp.c io_fprt.c io_fputc.c io_fputs.c io_fscan.c io_fseek.c io_fstat.c io_ftell.c io_fung.c io_ioctl.c io_misc.c io_pntf.c io_read.c io_scanf.c io_scanl.c io_spr.c io_sscan.c io_util.c io_vpr.c io_write.c
  group PSP Generic/include
    ../../../source/include/: gen_rev.h eds.h edserial.h edserprv.h eds_prv.h event.h event_prv.h fio.h fio_prv.h fpio_prv.h charq.h io.h ioctl.h io_prv.h io_rev.h ipc.h ipcrtprv.h ipc_pcb.h ipc_pcbv.h ipc_prv.h klog.h log.h log_prv.h lwsem.h lwevent.h lwevent_prv.h lwlog.h lwlog_prv.h lwmem.h lwmem_prv.h lwmsgq.h lwmsgq_prv.h lwtimer.h lwtimer_prv.h mem_prv.h message.h mmu.h mqx.h mqx_cnfg.h mqx_cpudef.h mqx_inc.h mqx_ioc.h mqx_prv.h mqx_str.h mqx_macros.h msg_prv.h mutex.h mutex_prv.h name.h name_prv.h partition.h partition_prv.h pcb.h posix.h queue.h sem.h sem_prv.h timer.h timer_prv.h watchdog.h watchdog_prv.h
  group PSP Generic/io
    ../../../source/io/: io_init.c io_inst.c io_instx.c io_ghand.c io_shand.c io_uinst.c
  group PSP Generic/string
    ../../../source/string/: strnlen.c str_utos.c
  group PSP Generic/tad
    ../../../source/tad/: tad.c tad.h
