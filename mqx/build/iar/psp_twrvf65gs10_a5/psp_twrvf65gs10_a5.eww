<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>psp_twrvf65gs10_a5</project><configuration>debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>psp_twrvf65gs10_a5</project><configuration>release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\psp_twrvf65gs10_a5.ewp</path></project></workspace>
