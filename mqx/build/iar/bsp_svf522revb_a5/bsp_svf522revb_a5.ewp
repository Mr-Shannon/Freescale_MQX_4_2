# IAR project bsp_svf522revb_a5.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../../source/io/asrc; ../../../source/io/cm; ../../../source/io/cm/vybrid; ../../../../config/svf522revb_a5; ../../../source/io/core_mutex; ../../../source/io/dcu4; ../../../source/io/dma; ../../../source/io/enet/macnet; ../../../source/io/enet/phy; ../../../source/io/enet; ../../../source/io/esai; ../../../source/io/esai/esai_fifo; ../../../source/io/esai/esai_vport; ../../../source/io/esdhc; ../../../source/io/fbdev; ../../../source/io/flashx/freescale; ../../../source/io/flashx; ../../../source/io/flashx/amd; ../../../source/io/flashx/fujitsu; ../../../source/io/flashx/spansion; ../../../source/io/flashx/atmel; ../../../source/io/flashx/istrata; ../../../source/io/flashx/sharp; ../../../source/io/can/flexcan; ../../../source/io/ftm; ../../../source/io/ftm/quaddec; ../../../source/io/hwtimer; ../../../source/io/i2c; ../../../source/io/i2c/polled; ../../../source/io/i2c/int; ../../../source/bsp/svf522revb_a5; ../../../../config/common; ../../../source/include; ../../../source/bsp/svf522revb_a5; ../../../source/io/enet; ../../../source/io/io_expander; ../../../source/io/io_mem; ../../../source/io/io_null; ../../../source/io/pipe; ../../../source/io/lpm/vybrid; ../../../source/io/lpm; ../../../source/io/lwadc; ../../../source/io/lwgpio; ../../../source/io/pcb/shmem; ../../../source/io/pcb; ../../../source/io/pcb/mqxa; ../../../source/io/qspi; ../../../source/io/sai; ../../../source/io/sai/dma; ../../../source/io/sdcard/sdcard_esdhc; ../../../source/io/sdcard; ../../../source/io/serial; ../../../source/io/spi; ../../../source/io/tfs; ../../../source/io/usb; ../../../source/psp/cortex_a/compiler/iar; ../../../source/psp/cortex_a/cpu; ../../../source/psp/cortex_a; ../../../../config/svf522revb_a5; ../../../../config/common; ../../../source/include; ../../../source/tad
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: ../../../source/psp/cortex_a/compiler/iar; ../../../source/psp/cortex_a; ../../../source/psp/cortex_a/core/A5; ../../../../config/svf522revb_a5; ../../../source/include; ../../../../config/common
  postbuild: "../../bat/bsp_svf522revb_a5.bat" "../../../.." "../../../../lib/svf522revb_a5.iar/debug/bsp" iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG=1
  postbuild: "../../bat/bsp_svf522revb_a5.bat" "../../../.." "../../../../lib/svf522revb_a5.iar/release/bsp" iar
  ILINK.IlinkOutputFile: libgeneric.out
  group Peripheral IO Drivers/asrc
    ../../../source/io/asrc/: asrc_vybrid.c asrc_vybrid.h asrc_vybrid_internal.c asrc_vybrid_prv.h vybrid_asrc_regs.h asrc.h asrc.c asrc_prv.h
  group Peripheral IO Drivers/core_mutex
    ../../../source/io/core_mutex/: sema4_vybrid.c core_mutex_sema4.c core_mutex_sema4.h core_mutex.c core_mutex.h sema4.h
  group Peripheral IO Drivers/dcu4
    ../../../source/io/dcu4/: dcu4_vybrid_a5.c dcu4.h dcu4.c dcu4_prv.h
  group Peripheral IO Drivers/dma
    ../../../source/io/dma/: edma_vybrid_a5.c dma.c dma.h edma.c edma.h edma_prv.h
  group Peripheral IO Drivers/enet
    ../../../source/io/enet/: enet_rev.h enetprv.h enaddr.c enclose.c enerr.c eninit.c enjoin.c enleave.c enmediactl.c enopen.c enrecv.c ensend.c enstat.c enstop.c enutil.c
  group Peripheral IO Drivers/enet/vybrid
    ../../../source/io/enet/macnet/: macnet_vybrid.c macnet_vybrid.h
  group Peripheral IO Drivers/enet/phy
    ../../../source/io/enet/phy/: phy_lan8720.c phy_lan8720.h
  group Peripheral IO Drivers/enet/macnet
    ../../../source/io/enet/macnet/: macnet_init.c macnet_join.c macnet_mii.c macnet_prv.h macnet_receive.c macnet_rejoin.c macnet_rev.h macnet_send.c macnet_stop.c macnet_util.c macnet_1588.c macnet_1588.h
  group Peripheral IO Drivers/esai
    ../../../source/io/esai/: esai_vybrid.h esai_vybrid.c esai_config.h
  group Peripheral IO Drivers/esai/esai_fifo
    ../../../source/io/esai/esai_fifo/: vybrid_esai_regs.h asrc_plugin.c esai_fifo_config.h esai_fifo_hw.h esai_fifo_hw.c esai_fifo_node.c esai_fifo_node.h esai_fifo_prv.h
  group Peripheral IO Drivers/esai/esai_vport
    ../../../source/io/esai/esai_vport/: esai_vport_vybrid.h esai_vport_vybrid.c esai_vport_vybrid_prv.h esai_fifo.h esai_vport.h esai_vport.c esai_vport_config.h esai_vport_prv.h
  group Peripheral IO Drivers/esdhc
    ../../../source/io/esdhc/: esdhc_vf65gs10_a5.c esdhc.h esdhc.c esdhc_prv.h
  group Peripheral IO Drivers/fbdev
    ../../../source/io/fbdev/: fbdev.h fbdev_dcu4.c fbdev_prv.h
  group Peripheral IO Drivers/flashx
    ../../../source/io/flashx/freescale/: flash_quadspi_spansion.c flash_vybrid.h
    ../../../source/io/flashx/: flashx.c flashx.h flashxprv.h
  group Peripheral IO Drivers/flashx/freescale
    ../../../source/io/flashx/freescale/: flash_quadspi.c flash_quadspi.h flash_quadspi_prv.h
  group Peripheral IO Drivers/flexcan
    ../../../source/io/can/flexcan/: fsl_flexcan_hal.c fsl_flexcan_hal.h fsl_flexcan_driver.c fsl_flexcan_driver.h fsl_flexcan_int.c fsl_flexcan_int.h
  group Peripheral IO Drivers/ftm
    ../../../source/io/ftm/: ftm_vybrid.h ftm_vybrid.c ftm.h
    ../../../source/io/ftm/quaddec/: ftm_quaddec_vybrid.c ftm_quaddec.c ftm_quaddec.h
  group Peripheral IO Drivers/hwtimer
    ../../../source/io/hwtimer/: hwtimer_vybrid_a5.c hwtimer_pit.c hwtimer_pit.h hwtimer_gtim.c hwtimer_gtim.h hwtimer.c hwtimer.h
  group Peripheral IO Drivers/i2c
    ../../../source/io/i2c/: i2c_qi2c_vybrid_a5.c qi2c.h i2c_qi2c.h i2c_qi2c_prv.h i2c.h
  group Peripheral IO Drivers/i2c/polled
    ../../../source/io/i2c/polled/: i2c_pol_qi2c.c i2c_pol_prv.h i2c_pol.c
  group Peripheral IO Drivers/i2c/int
    ../../../source/io/i2c/int/: i2c_int_qi2c.c i2c_int_prv.h i2c_int.c
  group Peripheral IO Drivers/io_expander
    ../../../source/io/io_expander/: io_exp_max7310.h max7310.c max7310_prv.h io_expander.h io_expander.c io_expander_prv.h
  group Peripheral IO Drivers/lwadc
    ../../../source/io/lwadc/: lwadc_vybrid.c lwadc.h
  group Peripheral IO Drivers/lwadc/vadc
    ../../../source/io/lwadc/: lwadc_vadc.c lwadc_vadc.h lwadc_vadc_prv.h
  group Peripheral IO Drivers/lwgpio
    ../../../source/io/lwgpio/: lwgpio_vgpio.c lwgpio_vgpio.h lwgpio.h lwgpio.c
  group Peripheral IO Drivers/qspi
    ../../../source/io/qspi/: qspi_vybrid_a5.c qspi.h qspi.c qspi_prv.h qspi_quadspi.h qspi_quadspi.c qspi_quadspi_prv.h
  group Peripheral IO Drivers/sai
    ../../../source/io/sai/: sai_vf65gs10.c sai_ksai.h sai_ksai_prv.h sai.h sai_audio.h
  group Peripheral IO Drivers/sai/dma
    ../../../source/io/sai/dma/: sai_dma_ksai.c sai_dma.c sai_dma_prv.h
  group Peripheral IO Drivers/sdcard
    ../../../source/io/sdcard/: sdcard.c sdcard.h sdcard_prv.h
  group Peripheral IO Drivers/sdcard/sdcard_esdhc
    ../../../source/io/sdcard/sdcard_esdhc/: sdcard_esdhc.c sdcard_esdhc.h
  group Peripheral IO Drivers/serial
    ../../../source/io/serial/: serl_vybrid.c serl_kuart.h io_sinit.c serial.h serinprv.h serplprv.h
  group Peripheral IO Drivers/serial/int
    ../../../source/io/serial/int/: serl_int_kuart.c serl_int.c
  group Peripheral IO Drivers/serial/polled
    ../../../source/io/serial/polled/: serl_pol_kuart.c serl_pol.c
  group Peripheral IO Drivers/serial/dma
    ../../../source/io/serial/dma/: serl_dma_kuart.c
  group Peripheral IO Drivers/spi
    ../../../source/io/spi/: spi_vybrid_a5.c spi_dspi_dma.h spi_dspi_dma.c spi_dspi_dma_prv.h spi_dspi_common.h spi_dspi_common.c spi.h spi.c spi_prv.h spi_dspi.h spi_dspi.c spi_dspi_prv.h
  group Peripheral IO Drivers/usb
    ../../../source/io/usb/: usb_vybrid.c usb_vybrid_device.c if_host_ehci.h if_host_khci.h if_dev_ehci.h if_dev_khci.h usb_bsp.h usb_install.c
  group Generic IO Drivers/cm
    ../../../source/io/cm/: cm.h cm.c cm_vybrid.h
    ../../../source/io/cm/vybrid/: bsp_clk_name.h bsp_clk_nodes.h bsp_clk_nodes_impl.h bsp_clk_nodes.c bsp_clk_api.h bsp_clk_api.c
  group Generic IO Drivers/io_mem
    ../../../source/io/io_mem/: io_mem.c io_mem.h iomemprv.h
  group Generic IO Drivers/io_null
    ../../../source/io/io_null/: io_null.c io_null.h ionulprv.h
  group Generic IO Drivers/iopipe
    ../../../source/io/pipe/: io_pipe.c io_pipe.h pipe_prv.h
  group Generic IO Drivers/lpm
    ../../../source/io/lpm/vybrid/: lpm_vybrid.h lpm_vybrid.c vybrid_wkpu.h vybrid_wkpu.c
    ../../../source/io/lpm/: lpm.h lpm_prv.h lpm.c
  group Generic IO Drivers/pcb
    ../../../source/io/pcb/shmem/: pcb_shm_vybrid_a5.c pcb_shm.c pcb_shm.h pcbshmv.h
    ../../../source/io/pcb/: io_pcb2.c io_pcb.c io_pcb.h iopcbprv.h
    ../../../source/io/pcb/mqxa/: pcb_mqxa.c pcb_mqxa.h pcbmqxav.h
  group Generic IO Drivers/tfs
    ../../../source/io/tfs/: tfs.c tfs.h tfs_prv.h
  group User Config
    ../../../../config/svf522revb_a5/: user_config.h
  group BSP Files
    ../../../source/bsp/svf522revb_a5/: bsp_cm.h bsp_cm.c init_enet.c init_dcu4.c init_fbdev.c init_esdhc.c init_gic.c init_gpio.c init_hw.c init_lpm.c init_lpm.h init_i2c.c init_sai.c init_sci.c init_sdcard.c init_spi.c init_qspi.c init_lwadc.c init_pcb_shm.c init_flashx.c init_usb.c init_ioexp.c init_ftm.c init_dma.c init_audio.c bsp.h bsp_prv.h bsp_rev.h init_bsp.c mqx_init.c mqx_main.c init_core_mutex.c svf522revb_a5.h
    ../../../../config/common/: small_ram_config.h smallest_config.h maximum_config.h verif_enabled_config.h
    ../../../source/include/: mqx.h
    ../../../source/io/enet/: ethernet.h enet.h enet_wifi.h
