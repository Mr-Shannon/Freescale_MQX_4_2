# IAR project iperf_twrk64f120m.ewp, settings and files
configuration int flash debug (ARM, debug)
  General.OGChipSelectEditMenu: MK63FN1M0xxx12 Freescale MK63FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../..; ../../../../../../lib/twrk64f120m.iar/debug/bsp/Generated_Code; ../../../../../../lib/twrk64f120m.iar/debug; ../../../../../../lib/twrk64f120m.iar/debug/bsp; ../../../../../../lib/twrk64f120m.iar/debug/psp; ../../../../../../lib/twrk64f120m.iar/debug/rtcs; ../../../../../../lib/twrk64f120m.iar/debug/shell
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: ../../../../../../lib/twrk64f120m.iar/debug/bsp/Generated_Code; ../../../../../../lib/twrk64f120m.iar/debug; ../../../../../../lib/twrk64f120m.iar/debug/bsp; ../../../../../../lib/twrk64f120m.iar/debug/psp; ../../../../../../lib/twrk64f120m.iar/debug/rtcs; ../../../../../../lib/twrk64f120m.iar/debug/shell
  ILINK.IlinkOutputFile: iperf.out
  ILINK.IlinkIcfFile: ../../../../../../lib/twrk64f120m.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/twrk64f120m.iar/debug/bsp/bsp.a; ../../../../../../lib/twrk64f120m.iar/debug/psp/psp.a; ../../../../../../lib/twrk64f120m.iar/debug/rtcs/rtcs.a; ../../../../../../lib/twrk64f120m.iar/debug/shell/shell.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration int flash release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1
  ICCARM.CCIncludePath2: ../../..; ../../../../../../lib/twrk64f120m.iar/release/bsp/Generated_Code; ../../../../../../lib/twrk64f120m.iar/release; ../../../../../../lib/twrk64f120m.iar/release/bsp; ../../../../../../lib/twrk64f120m.iar/release/psp; ../../../../../../lib/twrk64f120m.iar/release/rtcs; ../../../../../../lib/twrk64f120m.iar/release/shell
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG=1
  AARM.AUserIncludes: ../../../../../../lib/twrk64f120m.iar/release/bsp/Generated_Code; ../../../../../../lib/twrk64f120m.iar/release; ../../../../../../lib/twrk64f120m.iar/release/bsp; ../../../../../../lib/twrk64f120m.iar/release/psp; ../../../../../../lib/twrk64f120m.iar/release/rtcs; ../../../../../../lib/twrk64f120m.iar/release/shell
  ILINK.IlinkIcfFile: ../../../../../../lib/twrk64f120m.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/twrk64f120m.iar/release/bsp/bsp.a; ../../../../../../lib/twrk64f120m.iar/release/psp/psp.a; ../../../../../../lib/twrk64f120m.iar/release/rtcs/rtcs.a; ../../../../../../lib/twrk64f120m.iar/release/shell/shell.a
  group Sources
    ../../../: iperf.c iperf.h iperf_api.c iperf_api.h iperf_client_api.c iperf_client_api.h iperf_error.c iperf_error.h iperf_server_api.c iperf_server_api.h iperf_tcp.c iperf_tcp.h iperf_udp.c iperf_udp.h iperf_util.c iperf_util.h iqueue.h ilocale.c ilocale.h main.c main.h net.c net.h itimer.c itimer.h units.c units.h version.h
