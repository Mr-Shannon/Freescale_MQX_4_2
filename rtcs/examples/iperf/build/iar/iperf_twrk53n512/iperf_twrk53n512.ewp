# IAR project iperf_twrk53n512.ewp, settings and files
configuration int flash debug (ARM, debug)
  General.OGChipSelectEditMenu: MK53DN512Zxxx10 Freescale MK53DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../..; ../../../../../../lib/twrk53n512.iar/debug/bsp/Generated_Code; ../../../../../../lib/twrk53n512.iar/debug; ../../../../../../lib/twrk53n512.iar/debug/bsp; ../../../../../../lib/twrk53n512.iar/debug/psp; ../../../../../../lib/twrk53n512.iar/debug/rtcs; ../../../../../../lib/twrk53n512.iar/debug/shell
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: ../../../../../../lib/twrk53n512.iar/debug/bsp/Generated_Code; ../../../../../../lib/twrk53n512.iar/debug; ../../../../../../lib/twrk53n512.iar/debug/bsp; ../../../../../../lib/twrk53n512.iar/debug/psp; ../../../../../../lib/twrk53n512.iar/debug/rtcs; ../../../../../../lib/twrk53n512.iar/debug/shell
  ILINK.IlinkOutputFile: iperf.out
  ILINK.IlinkIcfFile: ../../../../../../lib/twrk53n512.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/twrk53n512.iar/debug/bsp/bsp.a; ../../../../../../lib/twrk53n512.iar/debug/psp/psp.a; ../../../../../../lib/twrk53n512.iar/debug/rtcs/rtcs.a; ../../../../../../lib/twrk53n512.iar/debug/shell/shell.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration int flash release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1
  ICCARM.CCIncludePath2: ../../..; ../../../../../../lib/twrk53n512.iar/release/bsp/Generated_Code; ../../../../../../lib/twrk53n512.iar/release; ../../../../../../lib/twrk53n512.iar/release/bsp; ../../../../../../lib/twrk53n512.iar/release/psp; ../../../../../../lib/twrk53n512.iar/release/rtcs; ../../../../../../lib/twrk53n512.iar/release/shell
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG=1
  AARM.AUserIncludes: ../../../../../../lib/twrk53n512.iar/release/bsp/Generated_Code; ../../../../../../lib/twrk53n512.iar/release; ../../../../../../lib/twrk53n512.iar/release/bsp; ../../../../../../lib/twrk53n512.iar/release/psp; ../../../../../../lib/twrk53n512.iar/release/rtcs; ../../../../../../lib/twrk53n512.iar/release/shell
  ILINK.IlinkIcfFile: ../../../../../../lib/twrk53n512.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/twrk53n512.iar/release/bsp/bsp.a; ../../../../../../lib/twrk53n512.iar/release/psp/psp.a; ../../../../../../lib/twrk53n512.iar/release/rtcs/rtcs.a; ../../../../../../lib/twrk53n512.iar/release/shell/shell.a
  group Sources
    ../../../: iperf.c iperf.h iperf_api.c iperf_api.h iperf_client_api.c iperf_client_api.h iperf_error.c iperf_error.h iperf_server_api.c iperf_server_api.h iperf_tcp.c iperf_tcp.h iperf_udp.c iperf_udp.h iperf_util.c iperf_util.h iqueue.h ilocale.c ilocale.h main.c main.h net.c net.h itimer.c itimer.h units.c units.h version.h
