<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>bsp_twrk60f120m</project><configuration>debug</configuration></member><member><project>psp_twrk60f120m</project><configuration>debug</configuration></member><member><project>rtcs_twrk60f120m</project><configuration>debug</configuration></member><member><project>shell_twrk60f120m</project><configuration>debug</configuration></member><member><project>iperf_twrk60f120m</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>bsp_twrk60f120m</project><configuration>release</configuration></member><member><project>psp_twrk60f120m</project><configuration>release</configuration></member><member><project>rtcs_twrk60f120m</project><configuration>release</configuration></member><member><project>shell_twrk60f120m</project><configuration>release</configuration></member><member><project>iperf_twrk60f120m</project><configuration>int flash release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\..\..\..\mqx\build\iar\bsp_twrk60f120m\bsp_twrk60f120m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\mqx\build\iar\psp_twrk60f120m\psp_twrk60f120m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\build\iar\rtcs_twrk60f120m\rtcs_twrk60f120m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\shell\build\iar\shell_twrk60f120m\shell_twrk60f120m.ewp</path></project><project><path>$WS_DIR$\iperf_twrk60f120m.ewp</path></project></workspace>
