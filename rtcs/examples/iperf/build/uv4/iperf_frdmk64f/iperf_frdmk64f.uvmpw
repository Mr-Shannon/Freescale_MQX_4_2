<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <WorkspaceName>WorkSpace</WorkspaceName>
<project><PathAndName>..\..\..\..\..\..\mqx\build\uv4\bsp_frdmk64f\bsp_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\..\mqx\build\uv4\psp_frdmk64f\psp_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\build\uv4\rtcs_frdmk64f\rtcs_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\..\shell\build\uv4\shell_frdmk64f\shell_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>iperf_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project></ProjectWorkspace>
