# Keil uVision project iperf_twrk65f180m.uvprojx, settings and files
target int flash debug (ARM-ADS)
  device: MK65FN2M0xxx18 Freescale Semiconductor
  pack: Keil.Kinetis_K60_DFP.1.3.0
  cpu: CPUTYPE("Cortex-M4.fp")
  output: iperf.axf +hex
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: -J../../.. 
-J../../../../../../lib/twrk65f180m.uv4/debug/bsp/Generated_Code 
-J../../../../../../lib/twrk65f180m.uv4/debug 
-J../../../../../../lib/twrk65f180m.uv4/debug/bsp 
-J../../../../../../lib/twrk65f180m.uv4/debug/psp 
-J../../../../../../lib/twrk65f180m.uv4/debug/rtcs 
-J../../../../../../lib/twrk65f180m.uv4/debug/shell 
-J#J 
--library_interface=none 
--library_type=standardlib 
--c99 
--diag_suppress=1296,186
  c include: ../../..;../../../../../../lib/twrk65f180m.uv4/debug/bsp/Generated_Code;../../../../../../lib/twrk65f180m.uv4/debug;../../../../../../lib/twrk65f180m.uv4/debug/bsp;../../../../../../lib/twrk65f180m.uv4/debug/psp;../../../../../../lib/twrk65f180m.uv4/debug/rtcs;../../../../../../lib/twrk65f180m.uv4/debug/shell
  asm misc: --cpreproc_opts '-D_DEBUG=1' --cpreproc
  asm include: ../../../../../../lib/twrk65f180m.uv4/debug/bsp/Generated_Code;../../../../../../lib/twrk65f180m.uv4/debug;../../../../../../lib/twrk65f180m.uv4/debug/bsp;../../../../../../lib/twrk65f180m.uv4/debug/psp;../../../../../../lib/twrk65f180m.uv4/debug/rtcs;../../../../../../lib/twrk65f180m.uv4/debug/shell
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../../../lib/twrk65f180m.uv4/debug/bsp/intflash.scf
  link misc: ../../../../../../lib/twrk65f180m.uv4/debug/bsp/bsp.lib 
../../../../../../lib/twrk65f180m.uv4/debug/psp/psp.lib 
../../../../../../lib/twrk65f180m.uv4/debug/rtcs/rtcs.lib 
../../../../../../lib/twrk65f180m.uv4/debug/shell/shell.lib 
../../../../../../lib/twrk65f180m.uv4/debug/bsp/bsp.lib(vectors.o) 
../../../../../../lib/twrk65f180m.uv4/debug/psp/psp.lib(linker_symbols.o) 
--keep linker_symbols.o(KERNEL_DATA_START) 
--keep linker_symbols.o(KERNEL_DATA_END) 
--keep linker_symbols.o(BOOT_STACK) 
--keep vectors.o(.vectors_rom) 
--remove 
--autoat 
--entry 
__boot
  group Sources
    ../../../: iperf.c iperf.h iperf_api.c iperf_api.h iperf_client_api.c iperf_client_api.h iperf_error.c iperf_error.h iperf_server_api.c iperf_server_api.h iperf_tcp.c iperf_tcp.h iperf_udp.c iperf_udp.h iperf_util.c iperf_util.h iqueue.h ilocale.c ilocale.h main.c main.h net.c net.h itimer.c itimer.h units.c units.h version.h
target int flash release (ARM-ADS)
  device: MK65FN2M0xxx18 Freescale Semiconductor
  cpu: CPUTYPE("Cortex-M4.fp")
  output: iperf.axf +hex
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG=1
  c misc: -J../../.. 
-J../../../../../../lib/twrk65f180m.uv4/release/bsp/Generated_Code 
-J../../../../../../lib/twrk65f180m.uv4/release 
-J../../../../../../lib/twrk65f180m.uv4/release/bsp 
-J../../../../../../lib/twrk65f180m.uv4/release/psp 
-J../../../../../../lib/twrk65f180m.uv4/release/rtcs 
-J../../../../../../lib/twrk65f180m.uv4/release/shell 
-J#J 
--library_interface=none 
--library_type=standardlib 
--c99 
--diag_suppress=1296,186
  c include: ../../..;../../../../../../lib/twrk65f180m.uv4/release/bsp/Generated_Code;../../../../../../lib/twrk65f180m.uv4/release;../../../../../../lib/twrk65f180m.uv4/release/bsp;../../../../../../lib/twrk65f180m.uv4/release/psp;../../../../../../lib/twrk65f180m.uv4/release/rtcs;../../../../../../lib/twrk65f180m.uv4/release/shell
  asm misc: --cpreproc_opts '-DNDEBUG=1' --cpreproc
  asm include: ../../../../../../lib/twrk65f180m.uv4/release/bsp/Generated_Code;../../../../../../lib/twrk65f180m.uv4/release;../../../../../../lib/twrk65f180m.uv4/release/bsp;../../../../../../lib/twrk65f180m.uv4/release/psp;../../../../../../lib/twrk65f180m.uv4/release/rtcs;../../../../../../lib/twrk65f180m.uv4/release/shell
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../../../lib/twrk65f180m.uv4/release/bsp/intflash.scf
  link misc: ../../../../../../lib/twrk65f180m.uv4/release/bsp/bsp.lib 
../../../../../../lib/twrk65f180m.uv4/release/psp/psp.lib 
../../../../../../lib/twrk65f180m.uv4/release/rtcs/rtcs.lib 
../../../../../../lib/twrk65f180m.uv4/release/shell/shell.lib 
../../../../../../lib/twrk65f180m.uv4/release/bsp/bsp.lib(vectors.o) 
../../../../../../lib/twrk65f180m.uv4/release/psp/psp.lib(linker_symbols.o) 
--keep linker_symbols.o(KERNEL_DATA_START) 
--keep linker_symbols.o(KERNEL_DATA_END) 
--keep linker_symbols.o(BOOT_STACK) 
--keep vectors.o(.vectors_rom) 
--remove 
--autoat 
--entry 
__boot
