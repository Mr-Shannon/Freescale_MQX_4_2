<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <WorkspaceName>WorkSpace</WorkspaceName>
<project><PathAndName>..\..\..\..\..\..\mqx\build\uv4\bsp_twrk64f120m\bsp_twrk64f120m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\..\mqx\build\uv4\psp_twrk64f120m\psp_twrk64f120m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\build\uv4\rtcs_twrk64f120m\rtcs_twrk64f120m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\..\shell\build\uv4\shell_twrk64f120m\shell_twrk64f120m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>iperf_twrk64f120m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project></ProjectWorkspace>
