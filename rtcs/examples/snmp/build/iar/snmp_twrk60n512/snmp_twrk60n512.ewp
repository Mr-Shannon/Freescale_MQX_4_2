# IAR project snmp_twrk60n512.ewp, settings and files
configuration int flash debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../..; ../../../../../../lib/twrk60n512.iar/debug/bsp/Generated_Code; ../../../../../../lib/twrk60n512.iar/debug; ../../../../../../lib/twrk60n512.iar/debug/bsp; ../../../../../../lib/twrk60n512.iar/debug/psp; ../../../../../../lib/twrk60n512.iar/debug/rtcs
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: ../../../../../../lib/twrk60n512.iar/debug/bsp/Generated_Code; ../../../../../../lib/twrk60n512.iar/debug; ../../../../../../lib/twrk60n512.iar/debug/bsp; ../../../../../../lib/twrk60n512.iar/debug/psp; ../../../../../../lib/twrk60n512.iar/debug/rtcs
  ILINK.IlinkOutputFile: snmp.out
  ILINK.IlinkIcfFile: ../../../../../../lib/twrk60n512.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/twrk60n512.iar/debug/bsp/bsp.a; ../../../../../../lib/twrk60n512.iar/debug/psp/psp.a; ../../../../../../lib/twrk60n512.iar/debug/rtcs/rtcs.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration int flash release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1
  ICCARM.CCIncludePath2: ../../..; ../../../../../../lib/twrk60n512.iar/release/bsp/Generated_Code; ../../../../../../lib/twrk60n512.iar/release; ../../../../../../lib/twrk60n512.iar/release/bsp; ../../../../../../lib/twrk60n512.iar/release/psp; ../../../../../../lib/twrk60n512.iar/release/rtcs
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG=1
  AARM.AUserIncludes: ../../../../../../lib/twrk60n512.iar/release/bsp/Generated_Code; ../../../../../../lib/twrk60n512.iar/release; ../../../../../../lib/twrk60n512.iar/release/bsp; ../../../../../../lib/twrk60n512.iar/release/psp; ../../../../../../lib/twrk60n512.iar/release/rtcs
  ILINK.IlinkIcfFile: ../../../../../../lib/twrk60n512.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/twrk60n512.iar/release/bsp/bsp.a; ../../../../../../lib/twrk60n512.iar/release/psp/psp.a; ../../../../../../lib/twrk60n512.iar/release/rtcs/rtcs.a
  group Sources
    ../../../: config.h snmp_demo.c snmp_demo.h snmptraps.c
