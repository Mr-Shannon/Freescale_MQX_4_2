# IAR project rtcs_shell_twrvf65gs10_a5.ewp, settings and files
configuration ddr debug (ARM, debug)
  General.OGChipSelectEditMenu: VF6xx_A5 Freescale VF6xx_A5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../..; ../../../../../../lib/twrvf65gs10_a5.iar/debug/bsp/Generated_Code; ../../../../../../lib/twrvf65gs10_a5.iar/debug; ../../../../../../lib/twrvf65gs10_a5.iar/debug/bsp; ../../../../../../lib/twrvf65gs10_a5.iar/debug/psp; ../../../../../../lib/twrvf65gs10_a5.iar/debug/mfs; ../../../../../../lib/twrvf65gs10_a5.iar/debug/rtcs; ../../../../../../lib/twrvf65gs10_a5.iar/debug/shell
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: ../../../../../../lib/twrvf65gs10_a5.iar/debug/bsp/Generated_Code; ../../../../../../lib/twrvf65gs10_a5.iar/debug; ../../../../../../lib/twrvf65gs10_a5.iar/debug/bsp; ../../../../../../lib/twrvf65gs10_a5.iar/debug/psp; ../../../../../../lib/twrvf65gs10_a5.iar/debug/mfs; ../../../../../../lib/twrvf65gs10_a5.iar/debug/rtcs; ../../../../../../lib/twrvf65gs10_a5.iar/debug/shell
  OBJCOPY.OOCOutputFile: twrvf65gs10_a5.bin
  ILINK.IlinkOutputFile: rtcs_shell.out
  ILINK.IlinkIcfFile: ../../../../../../lib/twrvf65gs10_a5.iar/debug/bsp/ddr.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/twrvf65gs10_a5.iar/debug/bsp/bsp.a; ../../../../../../lib/twrvf65gs10_a5.iar/debug/psp/psp.a; ../../../../../../lib/twrvf65gs10_a5.iar/debug/mfs/mfs.a; ../../../../../../lib/twrvf65gs10_a5.iar/debug/rtcs/rtcs.a; ../../../../../../lib/twrvf65gs10_a5.iar/debug/shell/shell.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration ddr release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1
  ICCARM.CCIncludePath2: ../../..; ../../../../../../lib/twrvf65gs10_a5.iar/release/bsp/Generated_Code; ../../../../../../lib/twrvf65gs10_a5.iar/release; ../../../../../../lib/twrvf65gs10_a5.iar/release/bsp; ../../../../../../lib/twrvf65gs10_a5.iar/release/psp; ../../../../../../lib/twrvf65gs10_a5.iar/release/mfs; ../../../../../../lib/twrvf65gs10_a5.iar/release/rtcs; ../../../../../../lib/twrvf65gs10_a5.iar/release/shell
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG=1
  AARM.AUserIncludes: ../../../../../../lib/twrvf65gs10_a5.iar/release/bsp/Generated_Code; ../../../../../../lib/twrvf65gs10_a5.iar/release; ../../../../../../lib/twrvf65gs10_a5.iar/release/bsp; ../../../../../../lib/twrvf65gs10_a5.iar/release/psp; ../../../../../../lib/twrvf65gs10_a5.iar/release/mfs; ../../../../../../lib/twrvf65gs10_a5.iar/release/rtcs; ../../../../../../lib/twrvf65gs10_a5.iar/release/shell
  ILINK.IlinkIcfFile: ../../../../../../lib/twrvf65gs10_a5.iar/release/bsp/ddr.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/twrvf65gs10_a5.iar/release/bsp/bsp.a; ../../../../../../lib/twrvf65gs10_a5.iar/release/psp/psp.a; ../../../../../../lib/twrvf65gs10_a5.iar/release/mfs/mfs.a; ../../../../../../lib/twrvf65gs10_a5.iar/release/rtcs/rtcs.a; ../../../../../../lib/twrvf65gs10_a5.iar/release/shell/shell.a
  group Sources
    ../../../: config.h demo.c demo_cmd.c _README.txt
