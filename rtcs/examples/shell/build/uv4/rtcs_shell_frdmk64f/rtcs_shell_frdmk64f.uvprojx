# Keil uVision project rtcs_shell_frdmk64f.uvprojx, settings and files
target int flash debug (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale Semiconductor
  cpu: CPUTYPE("Cortex-M4.fp")
  output: rtcs_shell.axf +hex
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: -J../../.. 
-J../../../../../../lib/frdmk64f.uv4/debug/bsp/Generated_Code 
-J../../../../../../lib/frdmk64f.uv4/debug 
-J../../../../../../lib/frdmk64f.uv4/debug/bsp 
-J../../../../../../lib/frdmk64f.uv4/debug/psp 
-J../../../../../../lib/frdmk64f.uv4/debug/mfs 
-J../../../../../../lib/frdmk64f.uv4/debug/rtcs 
-J../../../../../../lib/frdmk64f.uv4/debug/shell 
-J#J 
--library_interface=none 
--library_type=standardlib 
--c99 
--diag_suppress=1296,186
  c include: ../../..;../../../../../../lib/frdmk64f.uv4/debug/bsp/Generated_Code;../../../../../../lib/frdmk64f.uv4/debug;../../../../../../lib/frdmk64f.uv4/debug/bsp;../../../../../../lib/frdmk64f.uv4/debug/psp;../../../../../../lib/frdmk64f.uv4/debug/mfs;../../../../../../lib/frdmk64f.uv4/debug/rtcs;../../../../../../lib/frdmk64f.uv4/debug/shell
  asm misc: --cpreproc_opts '-D_DEBUG=1' --cpreproc
  asm include: ../../../../../../lib/frdmk64f.uv4/debug/bsp/Generated_Code;../../../../../../lib/frdmk64f.uv4/debug;../../../../../../lib/frdmk64f.uv4/debug/bsp;../../../../../../lib/frdmk64f.uv4/debug/psp;../../../../../../lib/frdmk64f.uv4/debug/mfs;../../../../../../lib/frdmk64f.uv4/debug/rtcs;../../../../../../lib/frdmk64f.uv4/debug/shell
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../../../lib/frdmk64f.uv4/debug/bsp/intflash.scf
  link misc: ../../../../../../lib/frdmk64f.uv4/debug/bsp/bsp.lib 
../../../../../../lib/frdmk64f.uv4/debug/psp/psp.lib 
../../../../../../lib/frdmk64f.uv4/debug/mfs/mfs.lib 
../../../../../../lib/frdmk64f.uv4/debug/rtcs/rtcs.lib 
../../../../../../lib/frdmk64f.uv4/debug/shell/shell.lib 
../../../../../../lib/frdmk64f.uv4/debug/bsp/bsp.lib(vectors.o) 
../../../../../../lib/frdmk64f.uv4/debug/psp/psp.lib(linker_symbols.o) 
--keep linker_symbols.o(KERNEL_DATA_START) 
--keep linker_symbols.o(KERNEL_DATA_END) 
--keep linker_symbols.o(BOOT_STACK) 
--keep vectors.o(.vectors_rom) 
--remove 
--autoat 
--entry 
__boot
  group Sources
    ../../../: config.h demo.c demo_cmd.c _README.txt
target int flash release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale Semiconductor
  cpu: CPUTYPE("Cortex-M4.fp")
  output: rtcs_shell.axf +hex
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG=1
  c misc: -J../../.. 
-J../../../../../../lib/frdmk64f.uv4/release/bsp/Generated_Code 
-J../../../../../../lib/frdmk64f.uv4/release 
-J../../../../../../lib/frdmk64f.uv4/release/bsp 
-J../../../../../../lib/frdmk64f.uv4/release/psp 
-J../../../../../../lib/frdmk64f.uv4/release/mfs 
-J../../../../../../lib/frdmk64f.uv4/release/rtcs 
-J../../../../../../lib/frdmk64f.uv4/release/shell 
-J#J 
--library_interface=none 
--library_type=standardlib 
--c99 
--diag_suppress=1296,186
  c include: ../../..;../../../../../../lib/frdmk64f.uv4/release/bsp/Generated_Code;../../../../../../lib/frdmk64f.uv4/release;../../../../../../lib/frdmk64f.uv4/release/bsp;../../../../../../lib/frdmk64f.uv4/release/psp;../../../../../../lib/frdmk64f.uv4/release/mfs;../../../../../../lib/frdmk64f.uv4/release/rtcs;../../../../../../lib/frdmk64f.uv4/release/shell
  asm misc: --cpreproc_opts '-DNDEBUG=1' --cpreproc
  asm include: ../../../../../../lib/frdmk64f.uv4/release/bsp/Generated_Code;../../../../../../lib/frdmk64f.uv4/release;../../../../../../lib/frdmk64f.uv4/release/bsp;../../../../../../lib/frdmk64f.uv4/release/psp;../../../../../../lib/frdmk64f.uv4/release/mfs;../../../../../../lib/frdmk64f.uv4/release/rtcs;../../../../../../lib/frdmk64f.uv4/release/shell
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../../../lib/frdmk64f.uv4/release/bsp/intflash.scf
  link misc: ../../../../../../lib/frdmk64f.uv4/release/bsp/bsp.lib 
../../../../../../lib/frdmk64f.uv4/release/psp/psp.lib 
../../../../../../lib/frdmk64f.uv4/release/mfs/mfs.lib 
../../../../../../lib/frdmk64f.uv4/release/rtcs/rtcs.lib 
../../../../../../lib/frdmk64f.uv4/release/shell/shell.lib 
../../../../../../lib/frdmk64f.uv4/release/bsp/bsp.lib(vectors.o) 
../../../../../../lib/frdmk64f.uv4/release/psp/psp.lib(linker_symbols.o) 
--keep linker_symbols.o(KERNEL_DATA_START) 
--keep linker_symbols.o(KERNEL_DATA_END) 
--keep linker_symbols.o(BOOT_STACK) 
--keep vectors.o(.vectors_rom) 
--remove 
--autoat 
--entry 
__boot
