# Keil uVision project rtcs_twrk60f120m.uvprojx, settings and files
target debug (ARM-ADS)
  device: MK60FN1M0xxx12 Freescale Semiconductor
  cpu: CPUTYPE("Cortex-M4.fp")
  output: rtcs.lib (library)
  AfterMake: ../../bat/rtcs_twrk60f120m.bat ../../../.. ../../../../lib/twrk60f120m.uv4/debug/rtcs uv4
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: -J../../../source/include 
-J../../../../ssl 
-J../../../../mqx/source/io/adc/kadc 
-J../../../../mqx/source/io/adc 
-J../../../../mqx/source/io/cm 
-J../../../../config/twrk60f120m 
-J../../../../mqx/source/io/dma 
-J../../../../mqx/source/io/enet/macnet 
-J../../../../mqx/source/io/enet/phy 
-J../../../../mqx/source/io/enet 
-J../../../../mqx/source/io/esdhc 
-J../../../../mqx/source/io/flashx/freescale 
-J../../../../mqx/source/io/flashx 
-J../../../../mqx/source/io/flashx/amd 
-J../../../../mqx/source/io/flashx/fujitsu 
-J../../../../mqx/source/io/flashx/spansion 
-J../../../../mqx/source/io/flashx/atmel 
-J../../../../mqx/source/io/flashx/istrata 
-J../../../../mqx/source/io/flashx/sharp 
-J../../../../mqx/source/io/can/flexcan 
-J../../../../mqx/source/io/gpio/kgpio 
-J../../../../mqx/source/io/gpio 
-J../../../../mqx/source/io/hwtimer 
-J../../../../mqx/source/io/i2c 
-J../../../../mqx/source/io/i2c/polled 
-J../../../../mqx/source/io/i2c/int 
-J../../../../mqx/source/bsp/twrk60f120m 
-J../../../../config/common 
-J../../../../mqx/source/include 
-J../../../../mqx/source/bsp/twrk60f120m 
-J../../../../mqx/source/io/enet 
-J../../../../mqx/source/io/debug 
-J../../../../mqx/source/io/io_mem 
-J../../../../mqx/source/io/io_null 
-J../../../../mqx/source/io/pipe 
-J../../../../mqx/source/io/lpm 
-J../../../../mqx/source/io/lwadc 
-J../../../../mqx/source/io/lwgpio 
-J../../../../mqx/source/io/nandflash/nfc 
-J../../../../mqx/source/io/nandflash 
-J../../../../mqx/source/io/pcb 
-J../../../../mqx/source/io/pcb/mqxa 
-J../../../../mqx/source/io/pccard 
-J../../../../mqx/source/io/pcflash 
-J../../../../mqx/source/io/rtc 
-J../../../../mqx/source/io/sai 
-J../../../../mqx/source/io/sai/dma 
-J../../../../mqx/source/io/sdcard/sdcard_esdhc 
-J../../../../mqx/source/io/sdcard/sdcard_spi 
-J../../../../mqx/source/io/sdcard 
-J../../../../mqx/source/io/serial 
-J../../../../mqx/source/io/spi 
-J../../../../mqx/source/io/tchres 
-J../../../../mqx/source/io/tfs 
-J../../../../mqx/source/io/timer 
-J../../../../mqx/source/io/usb 
-J../../../../mqx/source/io/usb_dcd 
-J../../../../mqx/source/io/usb_dcd/polled 
-J../../../../mqx/source/io/usb_dcd/int 
-J../../../../mqx/source/psp/cortex_m/compiler/rv_uv4 
-J../../../../mqx/source/psp/cortex_m/cpu 
-J../../../../mqx/source/psp/cortex_m 
-J../../../../config/twrk60f120m 
-J../../../../config/common 
-J../../../../mqx/source/include 
-J../../../../mqx/source/tad 
-J../../../../mfs/source/include 
-J#J 
--library_interface=none 
--library_type=standardlib 
--c99 
--diag_suppress=1296,186
  c include: ../../../source/include;../../../../ssl;../../../../mqx/source/io/adc/kadc;../../../../mqx/source/io/adc;../../../../mqx/source/io/cm;../../../../config/twrk60f120m;../../../../mqx/source/io/dma;../../../../mqx/source/io/enet/macnet;../../../../mqx/source/io/enet/phy;../../../../mqx/source/io/enet;../../../../mqx/source/io/esdhc;../../../../mqx/source/io/flashx/freescale;../../../../mqx/source/io/flashx;../../../../mqx/source/io/flashx/amd;../../../../mqx/source/io/flashx/fujitsu;../../../../mqx/source/io/flashx/spansion;../../../../mqx/source/io/flashx/atmel;../../../../mqx/source/io/flashx/istrata;../../../../mqx/source/io/flashx/sharp;../../../../mqx/source/io/can/flexcan;../../../../mqx/source/io/gpio/kgpio;../../../../mqx/source/io/gpio;../../../../mqx/source/io/hwtimer;../../../../mqx/source/io/i2c;../../../../mqx/source/io/i2c/polled;../../../../mqx/source/io/i2c/int;../../../../mqx/source/bsp/twrk60f120m;../../../../config/common;../../../../mqx/source/include;../../../../mqx/source/bsp/twrk60f120m;../../../../mqx/source/io/enet;../../../../mqx/source/io/debug;../../../../mqx/source/io/io_mem;../../../../mqx/source/io/io_null;../../../../mqx/source/io/pipe;../../../../mqx/source/io/lpm;../../../../mqx/source/io/lwadc;../../../../mqx/source/io/lwgpio;../../../../mqx/source/io/nandflash/nfc;../../../../mqx/source/io/nandflash;../../../../mqx/source/io/pcb;../../../../mqx/source/io/pcb/mqxa;../../../../mqx/source/io/pccard;../../../../mqx/source/io/pcflash;../../../../mqx/source/io/rtc;../../../../mqx/source/io/sai;../../../../mqx/source/io/sai/dma;../../../../mqx/source/io/sdcard/sdcard_esdhc;../../../../mqx/source/io/sdcard/sdcard_spi;../../../../mqx/source/io/sdcard;../../../../mqx/source/io/serial;../../../../mqx/source/io/spi;../../../../mqx/source/io/tchres;../../../../mqx/source/io/tfs;../../../../mqx/source/io/timer;../../../../mqx/source/io/usb;../../../../mqx/source/io/usb_dcd;../../../../mqx/source/io/usb_dcd/polled;../../../../mqx/source/io/usb_dcd/int;../../../../mqx/source/psp/cortex_m/compiler/rv_uv4;../../../../mqx/source/psp/cortex_m/cpu;../../../../mqx/source/psp/cortex_m;../../../../config/twrk60f120m;../../../../config/common;../../../../mqx/source/include;../../../../mqx/source/tad;../../../../mfs/source/include
  asm misc: --cpreproc_opts '-D_DEBUG=1' --cpreproc
  asm include: ../../../../mqx/source/io/debug;../../../../mqx/source/psp/cortex_m/compiler/rv_uv4;../../../../mqx/source/psp/cortex_m;../../../../mqx/source/psp/cortex_m/core/M4;../../../../config/twrk60f120m;../../../../mqx/source/include;../../../../config/common
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk60f120m.uv4\mqx\intflash.scf
  group RTCS Source/apps
    ../../../source/apps/: dhcpsrv.c echocln.c echosrv.c llmnrsrv.c ftpc.c ftpc_cmd.c ftpclnt.c ftpsrv.c ftpsrv_cmd.c ftpsrv_cmd_file.c ftpsrv_cmd_transfer.c ftpsrv_msg.c ftpsrv_supp.c ftpsrv_task.c httpsrv.c httpsrv_script.c httpsrv_supp.c httpsrv_task.c httpsrv_ws.c httpsrv_ws_api.c modem.c modem_supp.c rtcs_base64.c rtcs_smtp.c rtcs_sha1.c rtcs_ssl.c rtcs_utf8.c rtcs_util.c sntp.c sockio.c socknio.c telnetcln.c telnetcln_supp.c telnetcln_task.c telnetio.c telnetsrv.c telnetsrv_supp.c telnetsrv_task.c tftp_supp.c tftpcln.c tftpcln_supp.c tftpcln_task.c tftpsrv.c tftpsrv_supp.c tftpsrv_task.c dnscln.c
  group RTCS Source/if
    ../../../source/if/: arpcmd.c rtcs_if.c ifbootp.c ifdhcp.c ifppp.c ifstat.c iftraps.c iftunnel.c inet.c ipcfg.c iwcfg.c ping.c rtcs.c rtcscmd.c rtcsdela.c rtcsglob.c rtcs_hosts.c rtcsinit.c rtcslog0.c rtcslog1.c rtcsrand.c sock.c sock_close.c sock_dgram.c sock_options.c sock_select.c sock_stream.c sock_util.c soigmp.c soip.c solink.c getaddrinfo.c getnameinfo.c inet_ntop.c inet_pton.c ipcfg6.c ping6.c
  group RTCS Include
    ../../../source/include/: arp.h arp_prv.h arpif.h asn1.h bootp.h ccp.h chap.h checksum.h dhcp.h dhcp6.h dhcpcln6.h dhcpcln6_prv.h dhcp_prv.h dhcpsrv.h dhcpuprv.h dnscln.h dns_prv.h echocln.h echosrv.h llmnrsrv.h fcs16.h ftpc.h ftpsrv.h ftpsrv_msg.h ftpsrv_prv.h httpsrv.h httpsrv_prv.h httpsrv_script.h httpsrv_supp.h httpsrv_ws.h httpsrv_ws_prv.h icmp.h icmp_prv.h igmp.h ip.h ip_prv.h ip_if.h ipcfg.h ipcfg_prv.h iwcfg.h ipcp.h ip-e.h ipradix.h iptunnel.h lcp.h md5.h modem.h modem_prv.h modem_supp.h nat.h nat_prv.h nat_session.h natvers.h pap.h ppp.h ppp_prv.h pppfsm.h ppphdlc.h rip.h rip_prv.h route.h rtcs.h rtcs_assert.h rtcs_sock.h rtcs_err.h rtcs_stats.h rtcs_if.h rtcs_hosts.h rtcs_base64.h rtcs_in.h rtcs_prv.h rtcs_smtp.h rtcs_user_config.h rtcs_utf8.h rtcs_util.h rtcs_sha1.h rtcs_ssl.h rtcs25x.h rtcscfg.h rtcslog.h rtcspcb.h rtcsrtos.h rtcstime.h rtcsvers.h snmp.h snmpcfg.h socket.h tcp.h tcp_prv.h tcpip.h telnet.h telnetcln.h telnetcln_prv.h telnetsrv.h telnetsrv_prv.h tftp_prv.h tftpcln.h tftpcln_prv.h tftpsrv.h tftpsrv_prv.h ticker.h udp.h udp_prv.h icmp6.h icmp6_prv.h ip6.h ip6_if.h ip6_prv.h ip6_trace.h nd6.h mld.h addrinfo.h
  group RTCS Source/media
    ../../../source/media/: arp.c ipcp.c ipcpfsm.c ip-e.c proxyarp.c
  group RTCS Source/nat
    ../../../source/nat/: alggen.c dnat.c ifdnat.c ifnat.c nat.c nat_apply.c natalg.c natdata.c natevent.c natftp.c nattftp.c sonat.c
  group RTCS Source/os
    ../../../source/os/mqx/: rtcsdate.c rtcsmsec.c rtcsmsg.c rtcspart.c rtcssec.c rtcstask.c
  group RTCS Source/ppp
    ../../../source/ppp/: ccp.c chap.c gen16.c genmd5.c lcp.c md5.c md5step.c pap.c pktrx.c pkttx.c ppp.c pppfsm.c pppglob.c ppphdlc.c
  group RTCS Source/snmp
    ../../../source/snmp/: 1213.c mib.c mqxmib.c snmp.c trap_receivers.c traps.c
  group RTCS Source/tcpip
    ../../../source/tcpip/: bootcomm.c bootinit.c bootp.c checksum.c dhcpclnt.c dhcputil.c icmp.c igmp.c igmputil.c ip.c ip_reasm.c ip_if.c iplocal.c ipradix.c iproute.c iptunnel.c iputil.c rip.c route.c rtcspcb.c tcp.c tcp_buf.c tcp_clos.c tcp_rcv.c tcp_send.c tcpip.c ticker.c timer.c udp.c checksum6.c
target release (ARM-ADS)
  device: MK60FN1M0xxx12 Freescale Semiconductor
  cpu: CPUTYPE("Cortex-M4.fp")
  output: rtcs.lib (library)
  AfterMake: ../../bat/rtcs_twrk60f120m.bat ../../../.. ../../../../lib/twrk60f120m.uv4/release/rtcs uv4
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG=1
  c misc: as above
  c include: as above
  asm misc: --cpreproc_opts '-DNDEBUG=1' --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk60f120m.uv4\mqx\intflash.scf
