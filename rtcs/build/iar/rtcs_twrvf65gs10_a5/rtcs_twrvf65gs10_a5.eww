<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>rtcs_twrvf65gs10_a5</project><configuration>debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>rtcs_twrvf65gs10_a5</project><configuration>release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\rtcs_twrvf65gs10_a5.ewp</path></project></workspace>
