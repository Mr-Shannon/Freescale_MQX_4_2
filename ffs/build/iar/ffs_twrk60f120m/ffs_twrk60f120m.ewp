# IAR project ffs_twrk60f120m.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../../source/wearleveling/buffer_manager; ../../../source/wearleveling/common; ../../../source/wearleveling/ddi/common; ../../../source/wearleveling/ddi/data_drive; ../../../source/wearleveling/ddi/mapper; ../../../source/wearleveling/ddi/media; ../../../source; ../../../source/wearleveling/hal; ../../../source/wearleveling/nfc_wl; ../../../source/wearleveling/rtos/mqx; ../../../source/wearleveling; ../../../../mqx/source/io/adc/kadc; ../../../../mqx/source/io/adc; ../../../../mqx/source/io/cm; ../../../../config/twrk60f120m; ../../../../mqx/source/io/dma; ../../../../mqx/source/io/enet/macnet; ../../../../mqx/source/io/enet/phy; ../../../../mqx/source/io/enet; ../../../../mqx/source/io/esdhc; ../../../../mqx/source/io/flashx/freescale; ../../../../mqx/source/io/flashx; ../../../../mqx/source/io/flashx/amd; ../../../../mqx/source/io/flashx/fujitsu; ../../../../mqx/source/io/flashx/spansion; ../../../../mqx/source/io/flashx/atmel; ../../../../mqx/source/io/flashx/istrata; ../../../../mqx/source/io/flashx/sharp; ../../../../mqx/source/io/can/flexcan; ../../../../mqx/source/io/gpio/kgpio; ../../../../mqx/source/io/gpio; ../../../../mqx/source/io/hwtimer; ../../../../mqx/source/io/i2c; ../../../../mqx/source/io/i2c/polled; ../../../../mqx/source/io/i2c/int; ../../../../mqx/source/bsp/twrk60f120m; ../../../../config/common; ../../../../mqx/source/include; ../../../../mqx/source/bsp/twrk60f120m; ../../../../mqx/source/io/enet; ../../../../mqx/source/io/debug; ../../../../mqx/source/io/io_mem; ../../../../mqx/source/io/io_null; ../../../../mqx/source/io/pipe; ../../../../mqx/source/io/lpm; ../../../../mqx/source/io/lwadc; ../../../../mqx/source/io/lwgpio; ../../../../mqx/source/io/nandflash/nfc; ../../../../mqx/source/io/nandflash; ../../../../mqx/source/io/pcb; ../../../../mqx/source/io/pcb/mqxa; ../../../../mqx/source/io/pccard; ../../../../mqx/source/io/pcflash; ../../../../mqx/source/io/rtc; ../../../../mqx/source/io/sai; ../../../../mqx/source/io/sai/dma; ../../../../mqx/source/io/sdcard/sdcard_esdhc; ../../../../mqx/source/io/sdcard/sdcard_spi; ../../../../mqx/source/io/sdcard; ../../../../mqx/source/io/serial; ../../../../mqx/source/io/spi; ../../../../mqx/source/io/tchres; ../../../../mqx/source/io/tfs; ../../../../mqx/source/io/timer; ../../../../mqx/source/io/usb; ../../../../mqx/source/io/usb_dcd; ../../../../mqx/source/io/usb_dcd/polled; ../../../../mqx/source/io/usb_dcd/int; ../../../../mqx/source/psp/cortex_m/compiler/iar; ../../../../mqx/source/psp/cortex_m/cpu; ../../../../mqx/source/psp/cortex_m; ../../../../config/twrk60f120m; ../../../../config/common; ../../../../mqx/source/include; ../../../../mqx/source/tad
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: ../../../../mqx/source/io/debug; ../../../../mqx/source/psp/cortex_m/compiler/iar; ../../../../mqx/source/psp/cortex_m; ../../../../mqx/source/psp/cortex_m/core/M4; ../../../../config/twrk60f120m; ../../../../mqx/source/include; ../../../../config/common
  postbuild: "../../bat/ffs_twrk60f120m.bat" "../../../.." "../../../../lib/twrk60f120m.iar/debug/ffs" iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG=1
  postbuild: "../../bat/ffs_twrk60f120m.bat" "../../../.." "../../../../lib/twrk60f120m.iar/release/ffs" iar
  ILINK.IlinkOutputFile: libgeneric.out
  group FFS Source
    ../../../source/: nandflash_wl.cpp nandflash_wl.h nandflash_wl_ffs.h nandflash_wl_prv.h nandflash_wl_init.cpp nandflash_wl_config.h
  group FFS Source/wearleveling
    ../../../source/wearleveling/: auto_free.h ddi_media.h ddi_media_errordefs.h ddi_media_internal.h ddi_nand_media_definition.cpp drive_tags.h sectordef.h wl_common.cpp wl_common.h
  group FFS Source/wearleveling/buffer_manager
    ../../../source/wearleveling/buffer_manager/: media_buffer.h media_buffer_manager.cpp media_buffer_manager.h media_buffer_manager_init.cpp media_buffer_manager_internal.h
  group FFS Source/wearleveling/common
    ../../../source/wearleveling/common/: double_list.cpp double_list.h red_black_tree.cpp red_black_tree.h wlru.cpp wlru.h
  group FFS Source/wearleveling/ddi/common
    ../../../source/wearleveling/ddi/common/: ddi_block.cpp ddi_block.h ddi_nand_ddi.h deferred_task.cpp deferred_task.h ddi_metadata.cpp ddi_metadata.h ddi_page.cpp ddi_page.h page_order_map.cpp page_order_map.h
  group FFS Source/wearleveling/ddi/data_drive
    ../../../source/wearleveling/ddi/data_drive/: ddi_nand_data_drive.h ddi_nand_data_drive_erase.cpp ddi_nand_data_drive_get_info.cpp ddi_nand_data_drive_init.cpp ddi_nand_data_drive_read_sector.cpp ddi_nand_data_drive_set_info.cpp ddi_nand_ndd_flush.cpp ddi_nand_ndd_write_sector.cpp ddi_nand_nssm_get_entry.cpp nonsequential_sectors_map.cpp nonsequential_sectors_map.h
  group FFS Source/wearleveling/ddi/mapper
    ../../../source/wearleveling/ddi/mapper/: ddi_nand_mapper_get_info.cpp ddi_nand_mapper_utilities.cpp ddi_nand_mapper_zone_map_cache_lookup.cpp mapper.cpp mapper.h persistent_map.cpp persistent_map.h persistent_phy_map.cpp persistent_phy_map.h phy_map.cpp phy_map.h zone_map_cache.cpp zone_map_cache.h zone_map_section_page.cpp zone_map_section_page.h
  group FFS Source/wearleveling/ddi/media
    ../../../source/wearleveling/ddi/media/: bad_block_table.cpp bad_block_table.h ddi_nand_media.h ddi_nand_media_allocate.cpp ddi_nand_media_discover.cpp ddi_nand_media_get_info.cpp ddi_nand_media_init.cpp ddi_nand_media_regions.cpp ddi_nand_media_shutdown.cpp region.h
  group FFS Source/wearleveling/ddi_ldl
    ../../../source/wearleveling/ddi_ldl/: ddi_ldl_drive_get_info.cpp ddi_ldl_init.cpp ddi_ldl_iterator.cpp ddi_ldl_read.cpp ddi_ldl_util.cpp ddi_ldl_write.cpp
  group FFS Source/wearleveling/hal
    ../../../source/wearleveling/hal/: ddi_nand.h ddi_nand_hal.h ddi_nand_hal_common.cpp ddi_nand_hal_globals.cpp ddi_nand_hal_init.cpp ddi_nand_hal_internal.h ddi_nand_hal_nfcphymedia.cpp ddi_nand_hal_nfcphymedia.h
  group FFS Source/wearleveling/nfc_wl
    ../../../source/wearleveling/nfc_wl/: nfc_wl.cpp nfc_wl.h nfc_wl_dma.cpp nfc_wl_dma.h
  group FFS Source/wearleveling/rtos/mqx
    ../../../source/wearleveling/rtos/mqx/: deferred_task_queue.cpp deferred_task_queue.h errcode.cpp errcode.h mem_management.cpp mem_management.h mem_management_internal.h simple_mutex.cpp simple_mutex.h simple_timer.cpp simple_timer.h wl_types.h
