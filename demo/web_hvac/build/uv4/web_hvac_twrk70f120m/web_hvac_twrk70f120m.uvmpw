<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <WorkspaceName>WorkSpace</WorkspaceName>
<project><PathAndName>..\..\..\..\..\mqx\build\uv4\bsp_twrk70f120m\bsp_twrk70f120m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\mqx\build\uv4\psp_twrk70f120m\psp_twrk70f120m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\mfs\build\uv4\mfs_twrk70f120m\mfs_twrk70f120m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\rtcs\build\uv4\rtcs_twrk70f120m\rtcs_twrk70f120m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\shell\build\uv4\shell_twrk70f120m\shell_twrk70f120m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\usb\host\build\uv4\usbh_twrk70f120m\usbh_twrk70f120m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>web_hvac_twrk70f120m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project></ProjectWorkspace>
