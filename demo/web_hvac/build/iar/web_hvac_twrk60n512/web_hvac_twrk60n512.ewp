# IAR project web_hvac_twrk60n512.ewp, settings and files
configuration int flash debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../..; ../../../../../lib/twrk60n512.iar/debug/bsp/Generated_Code; ../../../../../lib/twrk60n512.iar/debug; ../../../../../lib/twrk60n512.iar/debug/bsp; ../../../../../lib/twrk60n512.iar/debug/psp; ../../../../../lib/twrk60n512.iar/debug/mfs; ../../../../../lib/twrk60n512.iar/debug/rtcs; ../../../../../lib/twrk60n512.iar/debug/shell; ../../../../../lib/twrk60n512.iar/debug/usb
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: ../../../../../lib/twrk60n512.iar/debug/bsp/Generated_Code; ../../../../../lib/twrk60n512.iar/debug; ../../../../../lib/twrk60n512.iar/debug/bsp; ../../../../../lib/twrk60n512.iar/debug/psp; ../../../../../lib/twrk60n512.iar/debug/mfs; ../../../../../lib/twrk60n512.iar/debug/rtcs; ../../../../../lib/twrk60n512.iar/debug/shell; ../../../../../lib/twrk60n512.iar/debug/usb
  ILINK.IlinkOutputFile: web_hvac.out
  ILINK.IlinkIcfFile: ../../../../../lib/twrk60n512.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../lib/twrk60n512.iar/debug/bsp/bsp.a; ../../../../../lib/twrk60n512.iar/debug/psp/psp.a; ../../../../../lib/twrk60n512.iar/debug/mfs/mfs.a; ../../../../../lib/twrk60n512.iar/debug/rtcs/rtcs.a; ../../../../../lib/twrk60n512.iar/debug/shell/shell.a; ../../../../../lib/twrk60n512.iar/debug/usb/usbh.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration int flash release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1
  ICCARM.CCIncludePath2: ../../..; ../../../../../lib/twrk60n512.iar/release/bsp/Generated_Code; ../../../../../lib/twrk60n512.iar/release; ../../../../../lib/twrk60n512.iar/release/bsp; ../../../../../lib/twrk60n512.iar/release/psp; ../../../../../lib/twrk60n512.iar/release/mfs; ../../../../../lib/twrk60n512.iar/release/rtcs; ../../../../../lib/twrk60n512.iar/release/shell; ../../../../../lib/twrk60n512.iar/release/usb
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG=1
  AARM.AUserIncludes: ../../../../../lib/twrk60n512.iar/release/bsp/Generated_Code; ../../../../../lib/twrk60n512.iar/release; ../../../../../lib/twrk60n512.iar/release/bsp; ../../../../../lib/twrk60n512.iar/release/psp; ../../../../../lib/twrk60n512.iar/release/mfs; ../../../../../lib/twrk60n512.iar/release/rtcs; ../../../../../lib/twrk60n512.iar/release/shell; ../../../../../lib/twrk60n512.iar/release/usb
  ILINK.IlinkIcfFile: ../../../../../lib/twrk60n512.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/twrk60n512.iar/release/bsp/bsp.a; ../../../../../lib/twrk60n512.iar/release/psp/psp.a; ../../../../../lib/twrk60n512.iar/release/mfs/mfs.a; ../../../../../lib/twrk60n512.iar/release/rtcs/rtcs.a; ../../../../../lib/twrk60n512.iar/release/shell/shell.a; ../../../../../lib/twrk60n512.iar/release/usb/usbh.a
  group Sources
    ../../../: command_lists.c hvac.h hvac_io.c hvac_private.h hvac_public.h hvac_shell_commands.c hvac_shell_commands.h hvac_task.c hvac_util.c logging_task.c logging_private.h logging_public.h rtcs.c shell_task.c switch_task.c tasks.c usb_file.c usb_file.h usb_task.c usb_task.h cgi.h cgi_hvac.c cgi_index.c tfs_data.c usb_classes.h usb_classes.c
