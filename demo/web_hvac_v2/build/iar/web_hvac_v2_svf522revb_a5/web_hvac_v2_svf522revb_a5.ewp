# IAR project web_hvac_v2_svf522revb_a5.ewp, settings and files
configuration ddr debug (ARM, debug)
  General.OGChipSelectEditMenu: SVF522R3K1CMK4_A5 Freescale SVF522R3K1CMK4_A5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../..; ../../../../../lib/svf522revb_a5.iar/debug/bsp/Generated_Code; ../../../../../lib/svf522revb_a5.iar/debug; ../../../../../lib/svf522revb_a5.iar/debug/bsp; ../../../../../lib/svf522revb_a5.iar/debug/psp; ../../../../../lib/svf522revb_a5.iar/debug/mfs; ../../../../../lib/svf522revb_a5.iar/debug/rtcs; ../../../../../lib/svf522revb_a5.iar/debug/shell; ../../../../../usb_v2/output/svf522revb_a5.iar/debug/usbh/mqx
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: ../../../../../lib/svf522revb_a5.iar/debug/bsp/Generated_Code; ../../../../../lib/svf522revb_a5.iar/debug; ../../../../../lib/svf522revb_a5.iar/debug/bsp; ../../../../../lib/svf522revb_a5.iar/debug/psp; ../../../../../lib/svf522revb_a5.iar/debug/mfs; ../../../../../lib/svf522revb_a5.iar/debug/rtcs; ../../../../../lib/svf522revb_a5.iar/debug/shell; ../../../../../usb_v2/output/svf522revb_a5.iar/debug/usbh/mqx
  OBJCOPY.OOCOutputFile: svf522revb_a5.bin
  ILINK.IlinkOutputFile: web_hvac_v2.out
  ILINK.IlinkIcfFile: ../../../../../lib/svf522revb_a5.iar/debug/bsp/ddr.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../lib/svf522revb_a5.iar/debug/bsp/bsp.a; ../../../../../lib/svf522revb_a5.iar/debug/psp/psp.a; ../../../../../lib/svf522revb_a5.iar/debug/mfs/mfs.a; ../../../../../lib/svf522revb_a5.iar/debug/rtcs/rtcs.a; ../../../../../lib/svf522revb_a5.iar/debug/shell/shell.a; ../../../../../usb_v2/output/svf522revb_a5.iar/debug/usbh/mqx/libusbh_mqx.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration ddr release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1
  ICCARM.CCIncludePath2: ../../..; ../../../../../lib/svf522revb_a5.iar/release/bsp/Generated_Code; ../../../../../lib/svf522revb_a5.iar/release; ../../../../../lib/svf522revb_a5.iar/release/bsp; ../../../../../lib/svf522revb_a5.iar/release/psp; ../../../../../lib/svf522revb_a5.iar/release/mfs; ../../../../../lib/svf522revb_a5.iar/release/rtcs; ../../../../../lib/svf522revb_a5.iar/release/shell; ../../../../../usb_v2/output/svf522revb_a5.iar/release/usbh/mqx
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG=1
  AARM.AUserIncludes: ../../../../../lib/svf522revb_a5.iar/release/bsp/Generated_Code; ../../../../../lib/svf522revb_a5.iar/release; ../../../../../lib/svf522revb_a5.iar/release/bsp; ../../../../../lib/svf522revb_a5.iar/release/psp; ../../../../../lib/svf522revb_a5.iar/release/mfs; ../../../../../lib/svf522revb_a5.iar/release/rtcs; ../../../../../lib/svf522revb_a5.iar/release/shell; ../../../../../usb_v2/output/svf522revb_a5.iar/release/usbh/mqx
  ILINK.IlinkIcfFile: ../../../../../lib/svf522revb_a5.iar/release/bsp/ddr.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/svf522revb_a5.iar/release/bsp/bsp.a; ../../../../../lib/svf522revb_a5.iar/release/psp/psp.a; ../../../../../lib/svf522revb_a5.iar/release/mfs/mfs.a; ../../../../../lib/svf522revb_a5.iar/release/rtcs/rtcs.a; ../../../../../lib/svf522revb_a5.iar/release/shell/shell.a; ../../../../../usb_v2/output/svf522revb_a5.iar/release/usbh/mqx/libusbh_mqx.a
configuration int ram debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ../../../../../lib/svf522revb_a5.iar/debug/bsp/intram.icf
configuration int ram release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG=1
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../lib/svf522revb_a5.iar/release/bsp/intram.icf
  ILINK.IlinkAdditionalLibs: as above
  group Sources
    ../../../: command_lists.c hvac.h hvac_io.c hvac_private.h hvac_public.h hvac_shell_commands.c hvac_shell_commands.h hvac_task.c hvac_util.c logging_task.c logging_private.h logging_public.h rtcs.c shell_task.c switch_task.c tasks.c usb_file.c usb_file.h usb_task.c usb_task.h cgi.h cgi_hvac.c cgi_index.c tfs_data.c usbmfs.c usbmfs.h usbmfspr.h
