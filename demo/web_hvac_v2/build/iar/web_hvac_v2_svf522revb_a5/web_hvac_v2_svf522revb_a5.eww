<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>bsp_svf522revb_a5</project><configuration>debug</configuration></member><member><project>psp_svf522revb_a5</project><configuration>debug</configuration></member><member><project>mfs_svf522revb_a5</project><configuration>debug</configuration></member><member><project>rtcs_svf522revb_a5</project><configuration>debug</configuration></member><member><project>shell_svf522revb_a5</project><configuration>debug</configuration></member><member><project>web_hvac_v2_svf522revb_a5</project><configuration>int ram debug</configuration></member><member><project>web_hvac_v2_svf522revb_a5</project><configuration>ddr debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>bsp_svf522revb_a5</project><configuration>release</configuration></member><member><project>psp_svf522revb_a5</project><configuration>release</configuration></member><member><project>mfs_svf522revb_a5</project><configuration>release</configuration></member><member><project>rtcs_svf522revb_a5</project><configuration>release</configuration></member><member><project>shell_svf522revb_a5</project><configuration>release</configuration></member><member><project>web_hvac_v2_svf522revb_a5</project><configuration>int ram release</configuration></member><member><project>web_hvac_v2_svf522revb_a5</project><configuration>ddr release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>usbh_mqx_svf522revb_a5</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>usbh_mqx_svf522revb_a5</project><configuration>Release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\..\..\mqx\build\iar\bsp_svf522revb_a5\bsp_svf522revb_a5.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\mqx\build\iar\psp_svf522revb_a5\psp_svf522revb_a5.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\mfs\build\iar\mfs_svf522revb_a5\mfs_svf522revb_a5.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\rtcs\build\iar\rtcs_svf522revb_a5\rtcs_svf522revb_a5.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\shell\build\iar\shell_svf522revb_a5\shell_svf522revb_a5.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\usb_v2\usb_core\host\build\iar\usbh_mqx_svf522revb_a5\usbh_mqx_svf522revb_a5.ewp</path></project><project><path>$WS_DIR$\web_hvac_v2_svf522revb_a5.ewp</path></project></workspace>
