# IAR project web_hvac_v2_twrk64f120m.ewp, settings and files
configuration int flash debug (ARM, debug)
  General.OGChipSelectEditMenu: MK63FN1M0xxx12 Freescale MK63FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../..; ../../../../../lib/twrk64f120m.iar/debug/bsp/Generated_Code; ../../../../../lib/twrk64f120m.iar/debug; ../../../../../lib/twrk64f120m.iar/debug/bsp; ../../../../../lib/twrk64f120m.iar/debug/psp; ../../../../../lib/twrk64f120m.iar/debug/mfs; ../../../../../lib/twrk64f120m.iar/debug/rtcs; ../../../../../lib/twrk64f120m.iar/debug/shell; ../../../../../usb_v2/output/twrk64f120m.iar/debug/usbh/mqx
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: ../../../../../lib/twrk64f120m.iar/debug/bsp/Generated_Code; ../../../../../lib/twrk64f120m.iar/debug; ../../../../../lib/twrk64f120m.iar/debug/bsp; ../../../../../lib/twrk64f120m.iar/debug/psp; ../../../../../lib/twrk64f120m.iar/debug/mfs; ../../../../../lib/twrk64f120m.iar/debug/rtcs; ../../../../../lib/twrk64f120m.iar/debug/shell; ../../../../../usb_v2/output/twrk64f120m.iar/debug/usbh/mqx
  ILINK.IlinkOutputFile: web_hvac_v2.out
  ILINK.IlinkIcfFile: ../../../../../lib/twrk64f120m.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../lib/twrk64f120m.iar/debug/bsp/bsp.a; ../../../../../lib/twrk64f120m.iar/debug/psp/psp.a; ../../../../../lib/twrk64f120m.iar/debug/mfs/mfs.a; ../../../../../lib/twrk64f120m.iar/debug/rtcs/rtcs.a; ../../../../../lib/twrk64f120m.iar/debug/shell/shell.a; ../../../../../usb_v2/output/twrk64f120m.iar/debug/usbh/mqx/libusbh_mqx.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration int flash release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1
  ICCARM.CCIncludePath2: ../../..; ../../../../../lib/twrk64f120m.iar/release/bsp/Generated_Code; ../../../../../lib/twrk64f120m.iar/release; ../../../../../lib/twrk64f120m.iar/release/bsp; ../../../../../lib/twrk64f120m.iar/release/psp; ../../../../../lib/twrk64f120m.iar/release/mfs; ../../../../../lib/twrk64f120m.iar/release/rtcs; ../../../../../lib/twrk64f120m.iar/release/shell; ../../../../../usb_v2/output/twrk64f120m.iar/release/usbh/mqx
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG=1
  AARM.AUserIncludes: ../../../../../lib/twrk64f120m.iar/release/bsp/Generated_Code; ../../../../../lib/twrk64f120m.iar/release; ../../../../../lib/twrk64f120m.iar/release/bsp; ../../../../../lib/twrk64f120m.iar/release/psp; ../../../../../lib/twrk64f120m.iar/release/mfs; ../../../../../lib/twrk64f120m.iar/release/rtcs; ../../../../../lib/twrk64f120m.iar/release/shell; ../../../../../usb_v2/output/twrk64f120m.iar/release/usbh/mqx
  ILINK.IlinkIcfFile: ../../../../../lib/twrk64f120m.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/twrk64f120m.iar/release/bsp/bsp.a; ../../../../../lib/twrk64f120m.iar/release/psp/psp.a; ../../../../../lib/twrk64f120m.iar/release/mfs/mfs.a; ../../../../../lib/twrk64f120m.iar/release/rtcs/rtcs.a; ../../../../../lib/twrk64f120m.iar/release/shell/shell.a; ../../../../../usb_v2/output/twrk64f120m.iar/release/usbh/mqx/libusbh_mqx.a
  group Sources
    ../../../: command_lists.c hvac.h hvac_io.c hvac_private.h hvac_public.h hvac_shell_commands.c hvac_shell_commands.h hvac_task.c hvac_util.c logging_task.c logging_private.h logging_public.h rtcs.c shell_task.c switch_task.c tasks.c usb_file.c usb_file.h usb_task.c usb_task.h cgi.h cgi_hvac.c cgi_index.c tfs_data.c usbmfs.c usbmfs.h usbmfspr.h
