# IAR project web_hvac_v2_frdmk64f.ewp, settings and files
configuration int flash debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../..; ../../../../../lib/frdmk64f.iar/debug/bsp/Generated_Code; ../../../../../lib/frdmk64f.iar/debug; ../../../../../lib/frdmk64f.iar/debug/bsp; ../../../../../lib/frdmk64f.iar/debug/psp; ../../../../../lib/frdmk64f.iar/debug/mfs; ../../../../../lib/frdmk64f.iar/debug/rtcs; ../../../../../lib/frdmk64f.iar/debug/shell; ../../../../../usb_v2/output/frdmk64f.iar/debug/usbh/mqx
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: ../../../../../lib/frdmk64f.iar/debug/bsp/Generated_Code; ../../../../../lib/frdmk64f.iar/debug; ../../../../../lib/frdmk64f.iar/debug/bsp; ../../../../../lib/frdmk64f.iar/debug/psp; ../../../../../lib/frdmk64f.iar/debug/mfs; ../../../../../lib/frdmk64f.iar/debug/rtcs; ../../../../../lib/frdmk64f.iar/debug/shell; ../../../../../usb_v2/output/frdmk64f.iar/debug/usbh/mqx
  ILINK.IlinkOutputFile: web_hvac_v2.out
  ILINK.IlinkIcfFile: ../../../../../lib/frdmk64f.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../lib/frdmk64f.iar/debug/bsp/bsp.a; ../../../../../lib/frdmk64f.iar/debug/psp/psp.a; ../../../../../lib/frdmk64f.iar/debug/mfs/mfs.a; ../../../../../lib/frdmk64f.iar/debug/rtcs/rtcs.a; ../../../../../lib/frdmk64f.iar/debug/shell/shell.a; ../../../../../usb_v2/output/frdmk64f.iar/debug/usbh/mqx/libusbh_mqx.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration int flash release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1
  ICCARM.CCIncludePath2: ../../..; ../../../../../lib/frdmk64f.iar/release/bsp/Generated_Code; ../../../../../lib/frdmk64f.iar/release; ../../../../../lib/frdmk64f.iar/release/bsp; ../../../../../lib/frdmk64f.iar/release/psp; ../../../../../lib/frdmk64f.iar/release/mfs; ../../../../../lib/frdmk64f.iar/release/rtcs; ../../../../../lib/frdmk64f.iar/release/shell; ../../../../../usb_v2/output/frdmk64f.iar/release/usbh/mqx
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG=1
  AARM.AUserIncludes: ../../../../../lib/frdmk64f.iar/release/bsp/Generated_Code; ../../../../../lib/frdmk64f.iar/release; ../../../../../lib/frdmk64f.iar/release/bsp; ../../../../../lib/frdmk64f.iar/release/psp; ../../../../../lib/frdmk64f.iar/release/mfs; ../../../../../lib/frdmk64f.iar/release/rtcs; ../../../../../lib/frdmk64f.iar/release/shell; ../../../../../usb_v2/output/frdmk64f.iar/release/usbh/mqx
  ILINK.IlinkIcfFile: ../../../../../lib/frdmk64f.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/frdmk64f.iar/release/bsp/bsp.a; ../../../../../lib/frdmk64f.iar/release/psp/psp.a; ../../../../../lib/frdmk64f.iar/release/mfs/mfs.a; ../../../../../lib/frdmk64f.iar/release/rtcs/rtcs.a; ../../../../../lib/frdmk64f.iar/release/shell/shell.a; ../../../../../usb_v2/output/frdmk64f.iar/release/usbh/mqx/libusbh_mqx.a
  group Sources
    ../../../: command_lists.c hvac.h hvac_io.c hvac_private.h hvac_public.h hvac_shell_commands.c hvac_shell_commands.h hvac_task.c hvac_util.c logging_task.c logging_private.h logging_public.h rtcs.c shell_task.c switch_task.c tasks.c usb_file.c usb_file.h usb_task.c usb_task.h cgi.h cgi_hvac.c cgi_index.c tfs_data.c usbmfs.c usbmfs.h usbmfspr.h
