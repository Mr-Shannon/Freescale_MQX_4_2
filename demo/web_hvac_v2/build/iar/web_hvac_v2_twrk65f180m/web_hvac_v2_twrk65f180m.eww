<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>bsp_twrk65f180m</project><configuration>debug</configuration></member><member><project>psp_twrk65f180m</project><configuration>debug</configuration></member><member><project>mfs_twrk65f180m</project><configuration>debug</configuration></member><member><project>rtcs_twrk65f180m</project><configuration>debug</configuration></member><member><project>shell_twrk65f180m</project><configuration>debug</configuration></member><member><project>web_hvac_v2_twrk65f180m</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>bsp_twrk65f180m</project><configuration>release</configuration></member><member><project>psp_twrk65f180m</project><configuration>release</configuration></member><member><project>mfs_twrk65f180m</project><configuration>release</configuration></member><member><project>rtcs_twrk65f180m</project><configuration>release</configuration></member><member><project>shell_twrk65f180m</project><configuration>release</configuration></member><member><project>web_hvac_v2_twrk65f180m</project><configuration>int flash release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>usbh_mqx_twrk65f180m</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>usbh_mqx_twrk65f180m</project><configuration>Release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\..\..\mqx\build\iar\bsp_twrk65f180m\bsp_twrk65f180m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\mqx\build\iar\psp_twrk65f180m\psp_twrk65f180m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\mfs\build\iar\mfs_twrk65f180m\mfs_twrk65f180m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\rtcs\build\iar\rtcs_twrk65f180m\rtcs_twrk65f180m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\shell\build\iar\shell_twrk65f180m\shell_twrk65f180m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\usb_v2\usb_core\host\build\iar\usbh_mqx_twrk65f180m\usbh_mqx_twrk65f180m.ewp</path></project><project><path>$WS_DIR$\web_hvac_v2_twrk65f180m.ewp</path></project></workspace>
