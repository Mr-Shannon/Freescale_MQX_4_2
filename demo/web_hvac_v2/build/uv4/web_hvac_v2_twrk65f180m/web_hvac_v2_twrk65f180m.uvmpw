<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <WorkspaceName>WorkSpace</WorkspaceName>
<project><PathAndName>..\..\..\..\..\mqx\build\uv4\bsp_twrk65f180m\bsp_twrk65f180m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\mqx\build\uv4\psp_twrk65f180m\psp_twrk65f180m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\mfs\build\uv4\mfs_twrk65f180m\mfs_twrk65f180m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\rtcs\build\uv4\rtcs_twrk65f180m\rtcs_twrk65f180m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\shell\build\uv4\shell_twrk65f180m\shell_twrk65f180m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\usb_v2\usb_core\host\build\uv4\usbh_mqx_twrk65f180m\usbh_mqx_twrk65f180m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>web_hvac_v2_twrk65f180m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project></ProjectWorkspace>
