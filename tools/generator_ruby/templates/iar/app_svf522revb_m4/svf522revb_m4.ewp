# IAR project svf522revb_m4.ewp, settings and files
configuration Int Ram Debug (ARM, debug)
  General.OGChipSelectEditMenu: SVF522R3K1CMK4_M4 Freescale SVF522R3K1CMK4_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: svf522revb_m4.bin
  ILINK.IlinkOutputFile: svf522revb_m4.out
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: __boot
configuration Int Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
