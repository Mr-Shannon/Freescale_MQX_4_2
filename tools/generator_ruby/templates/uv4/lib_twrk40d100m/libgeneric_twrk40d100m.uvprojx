# Keil uVision project libgeneric_twrk40d100m.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MK40DX256xxx10 Freescale Semiconductor
  cpu: IROM(0x00000000,0x40000) IROM2(0x10000000,0x40000) IRAM(0x20000000,0x8000) IRAM2(0x1FFF8000,0x8000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: XXXlibrarynameXXX_twrk40d100m_d (library)
  AfterMake: "..\bat\XXXlibrarynameXXX_twrk40d100m.bat" "..\..\..\lib\twrk40d100m.uv4\XXXlibrarynameXXX" uv4 debug twrk40d100m
  c flags: Optim=1 OneElfS=1
  c define: MQX_DISABLE_CONFIG_CHECK, _DEBUG
  c misc: --c99
  asm misc: --cpreproc --diag_suppress=1609
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: ..\..\..\lib\twrk40d100m.uv4\mqx\intflash.scf
target Release (ARM-ADS)
  device: MK40DX256xxx10 Freescale Semiconductor
  cpu: as above
  output: XXXlibrarynameXXX_twrk40d100m (library)
  AfterMake: "..\bat\XXXlibrarynameXXX_twrk40d100m.bat" "..\..\..\lib\twrk40d100m.uv4\XXXlibrarynameXXX" uv4 release twrk40d100m
  c flags: Optim=4 OneElfS=1
  c define: MQX_DISABLE_CONFIG_CHECK, NDEBUG
  c misc: --c99
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: ..\..\..\lib\twrk40d100m.uv4\mqx\intflash.scf
