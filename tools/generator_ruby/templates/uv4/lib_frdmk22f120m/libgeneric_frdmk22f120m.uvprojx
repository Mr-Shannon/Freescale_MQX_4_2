# Keil uVision project libgeneric_frdmk22f120m.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MK22DN512xxx5 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: XXXlibrarynameXXX_frdmk22f120m_d (library)
  c flags: Optim=1 OneElfS=1
  c misc: --c99
  asm misc: --cpreproc --diag_suppress=1609
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\frdmk22f120m.uv4\mqx\intflash.scf
target Release (ARM-ADS)
  device: MK22DN512xxx5 Freescale Semiconductor
  cpu: as above
  output: XXXlibrarynameXXX_frdmk22f120m (library)
  c flags: Optim=4 OneElfS=1
  c misc: --c99
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\frdmk22f120m.uv4\mqx\intflash.scf
