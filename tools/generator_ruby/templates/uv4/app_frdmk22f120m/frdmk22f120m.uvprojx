# Keil uVision project frdmk22f120m.uvprojx, settings and files
target Int Flash Debug (ARM-ADS)
  device: MK22DN512xxx5 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: XXXappnameXXX_intflash_d +hex
  c flags: Optim=1 OneElfS=1
  c misc: --c99
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../../lib/frdmk22f120m.uv4/debug/bsp/intflash.scf
  link misc: ../../../../../lib/frdmk22f120m.uv4/debug/psp/psp.lib(linker_symbols.o)
../../../../../lib/frdmk22f120m.uv4/debug/bsp/bsp.lib(vectors.o)
--keep linker_symbols.o(KERNEL_DATA_START)
--keep linker_symbols.o(KERNEL_DATA_END)
--keep linker_symbols.o(BOOT_STACK)
--keep vectors.o(.vectors_rom)
--diag_suppress=L6314W
target Int Flash Release (ARM-ADS)
  device: MK22DN512xxx5 Freescale Semiconductor
  cpu: as above
  output: XXXappnameXXX_inflash +hex
  c flags: Optim=4 OneElfS=1
  c misc: --c99
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../../lib/frdmk22f120m.uv4/release/bsp/intflash.scf
  link misc: ../../../../../lib/frdmk22f120m.uv4/release/psp/psp.lib(linker_symbols.o)
../../../../../lib/frdmk22f120m.uv4/release/bsp/bsp.lib(vectors.o)
--keep linker_symbols.o(KERNEL_DATA_START)
--keep linker_symbols.o(KERNEL_DATA_END)
--keep linker_symbols.o(BOOT_STACK)
--keep vectors.o(.vectors_rom)
--diag_suppress=L6314W
