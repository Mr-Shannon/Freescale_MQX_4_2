# Keil uVision project libgeneric_twrk53n512.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MK53DN512xxx10 Freescale Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: XXXlibrarynameXXX_twrk53n512_d (library)
  c flags: Optim=1 OneElfS=1
  c misc: --c99
  asm misc: --cpreproc --diag_suppress=1609
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ..\..\..\lib\twrk53n512.uv4\mqx\intflash.scf
target Release (ARM-ADS)
  device: MK53DN512xxx10 Freescale Semiconductor
  cpu: as above
  output: XXXlibrarynameXXX_twrk53n512 (library)
  c flags: Optim=4 OneElfS=1
  c misc: --c99
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ..\..\..\lib\twrk53n512.uv4\mqx\intflash.scf
