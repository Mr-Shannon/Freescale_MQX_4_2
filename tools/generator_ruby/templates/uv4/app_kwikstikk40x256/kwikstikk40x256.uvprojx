# Keil uVision project kwikstikk40x256.uvprojx, settings and files
target Int Flash Debug (ARM-ADS)
  device: MK40DX256xxx10 Freescale Semiconductor
  cpu: IROM(0x00000000,0x40000) IROM2(0x10000000,0x40000) IRAM(0x20000000,0x8000) IRAM2(0x1FFF8000,0x8000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: XXXappnameXXX_intflash_d +hex
  c flags: Optim=1 OneElfS=1
  c misc: --c99
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: ..\..\..\..\lib\kwikstikk40x256.uv4\bsp\intflash.scf
  link misc: ../../../../lib/kwikstikk40x256.uv4/debug/psp/psp.lib(linker_symbols.o)
../../../../lib/kwikstikk40x256.uv4/debug/bsp/bsp.lib(vectors.o)
--keep linker_symbols.o(KERNEL_DATA_START)
--keep linker_symbols.o(KERNEL_DATA_END)
--keep linker_symbols.o(BOOT_STACK)
--keep vectors.o(.vectors_rom)
--diag_suppress=L6314W
target Int Flash Release (ARM-ADS)
  device: MK40DX256xxx10 Freescale Semiconductor
  cpu: as above
  output: XXXappnameXXX_inflash +hex
  c flags: Optim=4 OneElfS=1
  c misc: --c99
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: ..\..\..\..\lib\kwikstikk40x256.uv4\bsp\intflash.scf
  link misc: ../../../../lib/kwikstikk40x256.uv4/release/psp/psp.lib(linker_symbols.o)
../../../../lib/kwikstikk40x256.uv4/release/bsp/bsp.lib(vectors.o)
--keep linker_symbols.o(KERNEL_DATA_START)
--keep linker_symbols.o(KERNEL_DATA_END)
--keep linker_symbols.o(BOOT_STACK)
--keep vectors.o(.vectors_rom)
--diag_suppress=L6314W
