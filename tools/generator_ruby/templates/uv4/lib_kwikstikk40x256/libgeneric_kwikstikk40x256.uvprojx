# Keil uVision project libgeneric_kwikstikk40x256.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MK40DX256xxx10 Freescale Semiconductor
  cpu: IROM(0x00000000,0x40000) IROM2(0x10000000,0x40000) IRAM(0x20000000,0x8000) IRAM2(0x1FFF8000,0x8000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: XXXlibrarynameXXX_kwikstikk40x256_d (library)
  c flags: Optim=1 OneElfS=1
  c misc: --c99
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: ..\..\..\lib\kwikstikk40x256.uv4\mqx\intflash.scf
target Release (ARM-ADS)
  device: MK40DX256xxx10 Freescale Semiconductor
  cpu: as above
  output: XXXlibrarynameXXX_kwikstikk40x256 (library)
  c flags: Optim=4 OneElfS=1
  c misc: --c99
  asm misc: --cpreproc --diag_suppress=1609
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: ..\..\..\lib\kwikstikk40x256.uv4\mqx\intflash.scf
