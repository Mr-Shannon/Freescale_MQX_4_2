# Keil uVision project libgeneric_twrk24f120m.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MK24FN256xxx12 Freescale
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: XXXlibrarynameXXX_twrk24f120m_d (library)
  c flags: Optim=1 OneElfS=1
  c misc: --c99
  asm misc: --cpreproc --diag_suppress=1609
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ..\..\..\lib\twrk24f120m.uv4\mqx\intflash.scf
target Release (ARM-ADS)
  device: MK24FN256xxx12 Freescale
  cpu: as above
  output: XXXlibrarynameXXX_twrk24f120m (library)
  c flags: Optim=4 OneElfS=1
  c misc: --c99
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ..\..\..\lib\twrk24f120m.uv4\mqx\intflash.scf
