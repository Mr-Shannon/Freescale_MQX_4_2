<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>mfs_twrk60d100m</project><configuration>debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>mfs_twrk60d100m</project><configuration>release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\mfs_twrk60d100m.ewp</path></project></workspace>
