<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>bsp_twrk21d50m</project><configuration>debug</configuration></member><member><project>psp_twrk21d50m</project><configuration>debug</configuration></member><member><project>mfs_twrk21d50m</project><configuration>debug</configuration></member><member><project>shell_twrk21d50m</project><configuration>debug</configuration></member><member><project>mfs_sdcard_twrk21d50m</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>bsp_twrk21d50m</project><configuration>release</configuration></member><member><project>psp_twrk21d50m</project><configuration>release</configuration></member><member><project>mfs_twrk21d50m</project><configuration>release</configuration></member><member><project>shell_twrk21d50m</project><configuration>release</configuration></member><member><project>mfs_sdcard_twrk21d50m</project><configuration>int flash release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\..\..\..\mqx\build\iar\bsp_twrk21d50m\bsp_twrk21d50m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\mqx\build\iar\psp_twrk21d50m\psp_twrk21d50m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\build\iar\mfs_twrk21d50m\mfs_twrk21d50m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\shell\build\iar\shell_twrk21d50m\shell_twrk21d50m.ewp</path></project><project><path>$WS_DIR$\mfs_sdcard_twrk21d50m.ewp</path></project></workspace>
