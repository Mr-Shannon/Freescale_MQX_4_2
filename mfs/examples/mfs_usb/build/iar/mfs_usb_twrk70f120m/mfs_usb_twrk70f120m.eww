<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>bsp_twrk70f120m</project><configuration>debug</configuration></member><member><project>psp_twrk70f120m</project><configuration>debug</configuration></member><member><project>mfs_twrk70f120m</project><configuration>debug</configuration></member><member><project>shell_twrk70f120m</project><configuration>debug</configuration></member><member><project>usbh_twrk70f120m</project><configuration>debug</configuration></member><member><project>mfs_usb_twrk70f120m</project><configuration>int flash sramdata debug</configuration></member><member><project>mfs_usb_twrk70f120m</project><configuration>int flash ddrdata debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>bsp_twrk70f120m</project><configuration>release</configuration></member><member><project>psp_twrk70f120m</project><configuration>release</configuration></member><member><project>mfs_twrk70f120m</project><configuration>release</configuration></member><member><project>shell_twrk70f120m</project><configuration>release</configuration></member><member><project>usbh_twrk70f120m</project><configuration>release</configuration></member><member><project>mfs_usb_twrk70f120m</project><configuration>int flash sramdata release</configuration></member><member><project>mfs_usb_twrk70f120m</project><configuration>int flash ddrdata release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\..\..\..\mqx\build\iar\bsp_twrk70f120m\bsp_twrk70f120m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\mqx\build\iar\psp_twrk70f120m\psp_twrk70f120m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\build\iar\mfs_twrk70f120m\mfs_twrk70f120m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\shell\build\iar\shell_twrk70f120m\shell_twrk70f120m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\usb\host\build\iar\usbh_twrk70f120m\usbh_twrk70f120m.ewp</path></project><project><path>$WS_DIR$\mfs_usb_twrk70f120m.ewp</path></project></workspace>
