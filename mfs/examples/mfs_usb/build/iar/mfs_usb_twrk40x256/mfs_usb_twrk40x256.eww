<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>bsp_twrk40x256</project><configuration>debug</configuration></member><member><project>psp_twrk40x256</project><configuration>debug</configuration></member><member><project>mfs_twrk40x256</project><configuration>debug</configuration></member><member><project>shell_twrk40x256</project><configuration>debug</configuration></member><member><project>usbh_twrk40x256</project><configuration>debug</configuration></member><member><project>mfs_usb_twrk40x256</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>bsp_twrk40x256</project><configuration>release</configuration></member><member><project>psp_twrk40x256</project><configuration>release</configuration></member><member><project>mfs_twrk40x256</project><configuration>release</configuration></member><member><project>shell_twrk40x256</project><configuration>release</configuration></member><member><project>usbh_twrk40x256</project><configuration>release</configuration></member><member><project>mfs_usb_twrk40x256</project><configuration>int flash release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\..\..\..\mqx\build\iar\bsp_twrk40x256\bsp_twrk40x256.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\mqx\build\iar\psp_twrk40x256\psp_twrk40x256.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\build\iar\mfs_twrk40x256\mfs_twrk40x256.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\shell\build\iar\shell_twrk40x256\shell_twrk40x256.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\usb\host\build\iar\usbh_twrk40x256\usbh_twrk40x256.ewp</path></project><project><path>$WS_DIR$\mfs_usb_twrk40x256.ewp</path></project></workspace>
