<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <WorkspaceName>WorkSpace</WorkspaceName>
<project><PathAndName>..\..\..\..\..\..\mqx\build\uv4\bsp_twrk40d100m\bsp_twrk40d100m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\..\mqx\build\uv4\psp_twrk40d100m\psp_twrk40d100m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\build\uv4\mfs_twrk40d100m\mfs_twrk40d100m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\..\shell\build\uv4\shell_twrk40d100m\shell_twrk40d100m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\..\usb\host\build\uv4\usbh_twrk40d100m\usbh_twrk40d100m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>mfs_usb_twrk40d100m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project></ProjectWorkspace>
