<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>bsp_twrk60n512</project><configuration>debug</configuration></member><member><project>psp_twrk60n512</project><configuration>debug</configuration></member><member><project>mfs_twrk60n512</project><configuration>debug</configuration></member><member><project>shell_twrk60n512</project><configuration>debug</configuration></member><member><project>mfs_ramdisk_twrk60n512</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>bsp_twrk60n512</project><configuration>release</configuration></member><member><project>psp_twrk60n512</project><configuration>release</configuration></member><member><project>mfs_twrk60n512</project><configuration>release</configuration></member><member><project>shell_twrk60n512</project><configuration>release</configuration></member><member><project>mfs_ramdisk_twrk60n512</project><configuration>int flash release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\..\..\..\mqx\build\iar\bsp_twrk60n512\bsp_twrk60n512.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\mqx\build\iar\psp_twrk60n512\psp_twrk60n512.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\build\iar\mfs_twrk60n512\mfs_twrk60n512.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\shell\build\iar\shell_twrk60n512\shell_twrk60n512.ewp</path></project><project><path>$WS_DIR$\mfs_ramdisk_twrk60n512.ewp</path></project></workspace>
