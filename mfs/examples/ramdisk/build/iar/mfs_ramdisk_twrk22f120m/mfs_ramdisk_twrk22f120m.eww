<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>bsp_twrk22f120m</project><configuration>debug</configuration></member><member><project>psp_twrk22f120m</project><configuration>debug</configuration></member><member><project>mfs_twrk22f120m</project><configuration>debug</configuration></member><member><project>shell_twrk22f120m</project><configuration>debug</configuration></member><member><project>mfs_ramdisk_twrk22f120m</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>bsp_twrk22f120m</project><configuration>release</configuration></member><member><project>psp_twrk22f120m</project><configuration>release</configuration></member><member><project>mfs_twrk22f120m</project><configuration>release</configuration></member><member><project>shell_twrk22f120m</project><configuration>release</configuration></member><member><project>mfs_ramdisk_twrk22f120m</project><configuration>int flash release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\..\..\..\mqx\build\iar\bsp_twrk22f120m\bsp_twrk22f120m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\mqx\build\iar\psp_twrk22f120m\psp_twrk22f120m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\build\iar\mfs_twrk22f120m\mfs_twrk22f120m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\shell\build\iar\shell_twrk22f120m\shell_twrk22f120m.ewp</path></project><project><path>$WS_DIR$\mfs_ramdisk_twrk22f120m.ewp</path></project></workspace>
