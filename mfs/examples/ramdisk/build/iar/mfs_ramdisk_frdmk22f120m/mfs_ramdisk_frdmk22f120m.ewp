# IAR project mfs_ramdisk_frdmk22f120m.ewp, settings and files
configuration int flash debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../../../../../lib/frdmk22f120m.iar/debug/bsp/Generated_Code; ../../../../../../lib/frdmk22f120m.iar/debug; ../../../../../../lib/frdmk22f120m.iar/debug/bsp; ../../../../../../lib/frdmk22f120m.iar/debug/psp; ../../../../../../lib/frdmk22f120m.iar/debug/mfs; ../../../../../../lib/frdmk22f120m.iar/debug/shell
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: frdmk22f120m.srec
  ILINK.IlinkOutputFile: mfs_ramdisk.out
  ILINK.IlinkIcfFile: ../../../../../../lib/frdmk22f120m.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/frdmk22f120m.iar/debug/bsp/bsp.a; ../../../../../../lib/frdmk22f120m.iar/debug/psp/psp.a; ../../../../../../lib/frdmk22f120m.iar/debug/mfs/mfs.a; ../../../../../../lib/frdmk22f120m.iar/debug/shell/shell.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration int flash release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1
  ICCARM.CCIncludePath2: ../../../../../../lib/frdmk22f120m.iar/release/bsp/Generated_Code; ../../../../../../lib/frdmk22f120m.iar/release; ../../../../../../lib/frdmk22f120m.iar/release/bsp; ../../../../../../lib/frdmk22f120m.iar/release/psp; ../../../../../../lib/frdmk22f120m.iar/release/mfs; ../../../../../../lib/frdmk22f120m.iar/release/shell
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG=1
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../lib/frdmk22f120m.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/frdmk22f120m.iar/release/bsp/bsp.a; ../../../../../../lib/frdmk22f120m.iar/release/psp/psp.a; ../../../../../../lib/frdmk22f120m.iar/release/mfs/mfs.a; ../../../../../../lib/frdmk22f120m.iar/release/shell/shell.a
  group Sources
    ../../../: tasks.c shell_task.c
