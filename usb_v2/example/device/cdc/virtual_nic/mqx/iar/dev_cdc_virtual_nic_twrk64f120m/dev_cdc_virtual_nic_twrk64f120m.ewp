# IAR project dev_cdc_virtual_nic_twrk64f120m.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CPU_MK64FN1M012=1; _DEBUG=1; CPU_MK64FN1M0VMD12=1
  ICCARM.CCDiagSuppress: Pe223,Pe021,Pe375,Pa082
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../output/twrk64f120m.iar/debug/usbd/mqx; ../../../../../../../../lib/twrk64f120m.iar/debug/bsp/Generated_Code; ../../../../../../../../lib/twrk64f120m.iar/debug/bsp/Sources; ../../../../../../../../lib/twrk64f120m.iar/debug; ../../../../../../../../lib/twrk64f120m.iar/debug/bsp; ../../../../../../../../lib/twrk64f120m.iar/debug/rtcs; ../../../../../../../../lib/twrk64f120m.iar/debug/psp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: dev_cdc_virtual_nic.out
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrk64f120m.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../output/twrk64f120m.iar/debug/usbd/mqx/libusbd_mqx.a; ../../../../../../../../lib/twrk64f120m.iar/debug/bsp/bsp.a; ../../../../../../../../lib/twrk64f120m.iar/debug/psp/psp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MK64FN1M012=1; CPU_MK64FN1M0VMD12=1
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../output/twrk64f120m.iar/release/usbd/mqx; ../../../../../../../../lib/twrk64f120m.iar/release/bsp/Generated_Code; ../../../../../../../../lib/twrk64f120m.iar/release/bsp/Sources; ../../../../../../../../lib/twrk64f120m.iar/release; ../../../../../../../../lib/twrk64f120m.iar/release/bsp; ../../../../../../../../lib/twrk64f120m.iar/release/rtcs; ../../../../../../../../lib/twrk64f120m.iar/release/psp
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrk64f120m.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../output/twrk64f120m.iar/release/usbd/mqx/libusbd_mqx.a; ../../../../../../../../lib/twrk64f120m.iar/release/bsp/bsp.a; ../../../../../../../../lib/twrk64f120m.iar/release/psp/psp.a
  group Sources/app
    ../../../: virtual_nic.c virtual_nic.h virtual_nic_enet.c virtual_nic_enet.h usb_descriptor.c usb_descriptor.h
