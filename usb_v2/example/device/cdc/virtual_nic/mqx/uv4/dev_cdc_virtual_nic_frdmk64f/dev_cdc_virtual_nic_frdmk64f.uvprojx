# Keil uVision project dev_cdc_virtual_nic_frdmk64f.uvprojx, settings and files
target Int Flash Debug (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale Semiconductor
  pack: Keil.Kinetis_K60_DFP.1.3.0
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2002FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: dev_cdc_virtual_nic +hex
  c flags: Optim=1 OneElfS=1
  c define: CPU_MK64FN1M012=1, _DEBUG=1, CPU_MK64FN1M0VMD12=1
  c misc: --library_interface=armcc   --library_type=standardlib  --c99  --diag_suppress=223,375
  c include: ../../..;../../../../../../../output/frdmk64f.uv4/debug/usbd/mqx;../../../../../../../../lib/frdmk64f.uv4/debug/bsp/Generated_Code;../../../../../../../../lib/frdmk64f.uv4/debug/bsp/Sources;../../../../../../../../lib/frdmk64f.uv4/debug;../../../../../../../../lib/frdmk64f.uv4/debug/bsp;../../../../../../../../lib/frdmk64f.uv4/debug/rtcs;../../../../../../../../lib/frdmk64f.uv4/debug/psp
  asm define: _DEBUG=1
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: ../../../../../../../../lib/frdmk64f.uv4/debug/bsp/intflash.scf
  link misc: ../../../../../../../output/frdmk64f.uv4/debug/usbd/mqx/libusbd_mqx.lib

../../../../../../../../lib/frdmk64f.uv4/debug/bsp/bsp.lib

../../../../../../../../lib/frdmk64f.uv4/debug/bsp/bsp.lib(vectors.o)

../../../../../../../../lib/frdmk64f.uv4/debug/psp/psp.lib

../../../../../../../../lib/frdmk64f.uv4/debug/psp/psp.lib(linker_symbols.o)

 --keep linker_symbols.o(KERNEL_DATA_START) 

 --keep linker_symbols.o(KERNEL_DATA_END) 

 --keep linker_symbols.o(BOOT_STACK) 

 --keep vectors.o(.vectors_rom) 

 --diag_suppress=L6314W 

 --remove 

 --autoat
  group Sources/app
    ../../../: virtual_nic.c virtual_nic.h virtual_nic_enet.c virtual_nic_enet.h usb_descriptor.c usb_descriptor.h
target Int Flash Release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale Semiconductor
  pack: Keil.Kinetis_K60_DFP.1.3.0
  cpu: as above
  output: dev_cdc_virtual_nic +hex
  c flags: Optim=4 OneElfS=1
  c define: CPU_MK64FN1M012=1, CPU_MK64FN1M0VMD12=1
  c misc: as above
  c include: ../../..;../../../../../../../output/frdmk64f.uv4/release/usbd/mqx;../../../../../../../../lib/frdmk64f.uv4/release/bsp/Generated_Code;../../../../../../../../lib/frdmk64f.uv4/release/bsp/Sources;../../../../../../../../lib/frdmk64f.uv4/release;../../../../../../../../lib/frdmk64f.uv4/release/bsp;../../../../../../../../lib/frdmk64f.uv4/release/rtcs;../../../../../../../../lib/frdmk64f.uv4/release/psp
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: ../../../../../../../../lib/frdmk64f.uv4/release/bsp/intflash.scf
  link misc: ../../../../../../../output/frdmk64f.uv4/release/usbd/mqx/libusbd_mqx.lib

../../../../../../../../lib/frdmk64f.uv4/release/bsp/bsp.lib

../../../../../../../../lib/frdmk64f.uv4/release/bsp/bsp.lib(vectors.o)

../../../../../../../../lib/frdmk64f.uv4/release/psp/psp.lib

../../../../../../../../lib/frdmk64f.uv4/release/psp/psp.lib(linker_symbols.o)

 --keep linker_symbols.o(KERNEL_DATA_START) 

 --keep linker_symbols.o(KERNEL_DATA_END) 

 --keep linker_symbols.o(BOOT_STACK) 

 --keep vectors.o(.vectors_rom) 

 --diag_suppress=L6314W 

 --remove 

 --autoat
