# Keil uVision project dev_cdc_virtual_nic_twrk65f180m.uvprojx, settings and files
target Int Flash Debug (ARM-ADS)
  device: MK65FN2M0xxx18 Freescale
  pack: Keil.Kinetis_K60_DFP.1.3.0
  cpu: IROM(0x00000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: dev_cdc_virtual_nic +hex
  c flags: Optim=1 OneElfS=1
  c define: CPU_MK65F18=1, CPU_MK65FN2M0VMI18=1, _DEBUG=1
  c misc: --library_interface=armcc   --library_type=standardlib  --c99  --diag_suppress=223,375
  c include: ../../..;../../../../../../../output/twrk65f180m.uv4/debug/usbd/mqx;../../../../../../../../lib/twrk65f180m.uv4/debug/bsp/Generated_Code;../../../../../../../../lib/twrk65f180m.uv4/debug/bsp/Sources;../../../../../../../../lib/twrk65f180m.uv4/debug;../../../../../../../../lib/twrk65f180m.uv4/debug/bsp;../../../../../../../../lib/twrk65f180m.uv4/debug/rtcs;../../../../../../../../lib/twrk65f180m.uv4/debug/psp
  asm define: _DEBUG=1
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../../../../../lib/twrk65f180m.uv4/debug/bsp/intflash.scf
  link misc: ../../../../../../../output/twrk65f180m.uv4/debug/usbd/mqx/libusbd_mqx.lib

../../../../../../../../lib/twrk65f180m.uv4/debug/bsp/bsp.lib

../../../../../../../../lib/twrk65f180m.uv4/debug/bsp/bsp.lib(vectors.o)

../../../../../../../../lib/twrk65f180m.uv4/debug/psp/psp.lib

../../../../../../../../lib/twrk65f180m.uv4/debug/psp/psp.lib(linker_symbols.o)

 --keep linker_symbols.o(KERNEL_DATA_START) 

 --keep linker_symbols.o(KERNEL_DATA_END) 

 --keep linker_symbols.o(BOOT_STACK) 

 --keep vectors.o(.vectors_rom) 

 --diag_suppress=L6314W 

 --remove 

 --autoat
  group Sources/app
    ../../../: virtual_nic.c virtual_nic.h virtual_nic_enet.c virtual_nic_enet.h usb_descriptor.c usb_descriptor.h
target Int Flash Release (ARM-ADS)
  device: MK65FN2M0xxx18 Freescale
  pack: Keil.Kinetis_K60_DFP.1.3.0
  cpu: as above
  output: dev_cdc_virtual_nic +hex
  c flags: Optim=4 OneElfS=1
  c define: CPU_MK65F18=1, CPU_MK65FN2M0VMI18=1
  c misc: as above
  c include: ../../..;../../../../../../../output/twrk65f180m.uv4/release/usbd/mqx;../../../../../../../../lib/twrk65f180m.uv4/release/bsp/Generated_Code;../../../../../../../../lib/twrk65f180m.uv4/release/bsp/Sources;../../../../../../../../lib/twrk65f180m.uv4/release;../../../../../../../../lib/twrk65f180m.uv4/release/bsp;../../../../../../../../lib/twrk65f180m.uv4/release/rtcs;../../../../../../../../lib/twrk65f180m.uv4/release/psp
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../../../../../lib/twrk65f180m.uv4/release/bsp/intflash.scf
  link misc: ../../../../../../../output/twrk65f180m.uv4/release/usbd/mqx/libusbd_mqx.lib

../../../../../../../../lib/twrk65f180m.uv4/release/bsp/bsp.lib

../../../../../../../../lib/twrk65f180m.uv4/release/bsp/bsp.lib(vectors.o)

../../../../../../../../lib/twrk65f180m.uv4/release/psp/psp.lib

../../../../../../../../lib/twrk65f180m.uv4/release/psp/psp.lib(linker_symbols.o)

 --keep linker_symbols.o(KERNEL_DATA_START) 

 --keep linker_symbols.o(KERNEL_DATA_END) 

 --keep linker_symbols.o(BOOT_STACK) 

 --keep vectors.o(.vectors_rom) 

 --diag_suppress=L6314W 

 --remove 

 --autoat
