# IAR project dev_phdc_weighscale_twrk65f180m.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK65FN2M0xxx18 Freescale MK65FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CPU_MK65F18=1; CPU_MK65FN2M0VMI18=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pe223,Pe021,Pe375,Pa082
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../output/twrk65f180m.iar/debug/usbd/mqx; ../../../../../../../../lib/twrk65f180m.iar/debug/bsp/Generated_Code; ../../../../../../../../lib/twrk65f180m.iar/debug/bsp/Sources; ../../../../../../../../lib/twrk65f180m.iar/debug; ../../../../../../../../lib/twrk65f180m.iar/debug/bsp; ../../../../../../../../lib/twrk65f180m.iar/debug/psp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: twrk65f180m.srec
  ILINK.IlinkOutputFile: dev_phdc_weighscale.out
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrk65f180m.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../output/twrk65f180m.iar/debug/usbd/mqx/libusbd_mqx.a; ../../../../../../../../lib/twrk65f180m.iar/debug/bsp/bsp.a; ../../../../../../../../lib/twrk65f180m.iar/debug/psp/psp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MK65F18=1; CPU_MK65FN2M0VMI18=1
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../output/twrk65f180m.iar/release/usbd/mqx; ../../../../../../../../lib/twrk65f180m.iar/release/bsp/Generated_Code; ../../../../../../../../lib/twrk65f180m.iar/release/bsp/Sources; ../../../../../../../../lib/twrk65f180m.iar/release; ../../../../../../../../lib/twrk65f180m.iar/release/bsp; ../../../../../../../../lib/twrk65f180m.iar/release/psp
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrk65f180m.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../output/twrk65f180m.iar/release/usbd/mqx/libusbd_mqx.a; ../../../../../../../../lib/twrk65f180m.iar/release/bsp/bsp.a; ../../../../../../../../lib/twrk65f180m.iar/release/psp/psp.a
configuration Int Ram Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrk65f180m.iar/debug/bsp/ram.icf
configuration Int Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MK65F18=1; CPU_MK65FN2M0VMI18=1
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrk65f180m.iar/release/bsp/ram.icf
  ILINK.IlinkAdditionalLibs: as above
  group Sources/app
    ../../../: phd_com_model.c phd_com_model.h weighscale.c weighscale.h ieee11073_nom_codes.h ieee11073_phd_types.h usb_descriptor.c usb_descriptor.h
