# IAR project dev_hid_audio_svf522revb_m4.ewp, settings and files
configuration Int Ram Debug (ARM, debug)
  General.OGChipSelectEditMenu: SVF522R3K1CMK4_M4 Freescale SVF522R3K1CMK4_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CPU_SVF522R3K_M4=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../output/svf522revb_m4.iar/debug/usbd/mqx; ../../../../../../../../lib/svf522revb_m4.iar/debug/bsp/Generated_Code; ../../../../../../../../lib/svf522revb_m4.iar/debug/bsp/Sources; ../../../../../../../../lib/svf522revb_m4.iar/debug; ../../../../../../../../lib/svf522revb_m4.iar/debug/bsp; ../../../../../../../../lib/svf522revb_m4.iar/debug/psp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: svf522revb_m4.bin
  ILINK.IlinkOutputFile: dev_hid_audio.out
  ILINK.IlinkIcfFile: ../../../../../../../../lib/svf522revb_m4.iar/debug/bsp/ram.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../output/svf522revb_m4.iar/debug/usbd/mqx/libusbd_mqx.a; ../../../../../../../../lib/svf522revb_m4.iar/debug/bsp/bsp.a; ../../../../../../../../lib/svf522revb_m4.iar/debug/psp/psp.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration Int Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_SVF522R3K_M4=1
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../output/svf522revb_m4.iar/release/usbd/mqx; ../../../../../../../../lib/svf522revb_m4.iar/release/bsp/Generated_Code; ../../../../../../../../lib/svf522revb_m4.iar/release/bsp/Sources; ../../../../../../../../lib/svf522revb_m4.iar/release; ../../../../../../../../lib/svf522revb_m4.iar/release/bsp; ../../../../../../../../lib/svf522revb_m4.iar/release/psp
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../../../lib/svf522revb_m4.iar/release/bsp/ram.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../output/svf522revb_m4.iar/release/usbd/mqx/libusbd_mqx.a; ../../../../../../../../lib/svf522revb_m4.iar/release/bsp/bsp.a; ../../../../../../../../lib/svf522revb_m4.iar/release/psp/psp.a
  group Sources/app
    ../../../: audio_generator.c audio_generator.h audio_data.c mouse.c mouse.h usb_request.c usb_request.h composite_app.c composite_app.h usb_descriptor.c usb_descriptor.h
