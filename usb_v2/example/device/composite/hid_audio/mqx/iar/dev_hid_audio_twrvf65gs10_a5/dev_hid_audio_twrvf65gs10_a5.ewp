# IAR project dev_hid_audio_twrvf65gs10_a5.ewp, settings and files
configuration DDR Debug (ARM, debug)
  General.OGChipSelectEditMenu: VF6xx_A5 Freescale VF6xx_A5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DDR_DATA_TARGET; CPU_VF65GS10_A5=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174,Pe223
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../output/twrvf65gs10_a5.iar/debug/usbd/mqx; ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/bsp/Generated_Code; ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/bsp/Sources; ../../../../../../../../lib/twrvf65gs10_a5.iar/debug; ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/bsp; ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/psp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: twrvf65gs10_a5.bin
  ILINK.IlinkOutputFile: dev_hid_audio.out
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/bsp/ddr.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../output/twrvf65gs10_a5.iar/debug/usbd/mqx/libusbd_mqx.a; ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/bsp/bsp.a; ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/psp/psp.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration DDR Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DDR_DATA_TARGET; CPU_VF65GS10_A5=1
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../output/twrvf65gs10_a5.iar/release/usbd/mqx; ../../../../../../../../lib/twrvf65gs10_a5.iar/release/bsp/Generated_Code; ../../../../../../../../lib/twrvf65gs10_a5.iar/release/bsp/Sources; ../../../../../../../../lib/twrvf65gs10_a5.iar/release; ../../../../../../../../lib/twrvf65gs10_a5.iar/release/bsp; ../../../../../../../../lib/twrvf65gs10_a5.iar/release/psp
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrvf65gs10_a5.iar/release/bsp/ddr.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../output/twrvf65gs10_a5.iar/release/usbd/mqx/libusbd_mqx.a; ../../../../../../../../lib/twrvf65gs10_a5.iar/release/bsp/bsp.a; ../../../../../../../../lib/twrvf65gs10_a5.iar/release/psp/psp.a
configuration Int Ram Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SRAM_DATA_TARGET; CPU_VF65GS10_A5=1; _DEBUG=1
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/bsp/intram.icf
configuration Int Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SRAM_DATA_TARGET; CPU_VF65GS10_A5=1
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrvf65gs10_a5.iar/release/bsp/intram.icf
  ILINK.IlinkAdditionalLibs: as above
  group Sources/app
    ../../../: audio_generator.c audio_generator.h audio_data.c mouse.c mouse.h usb_request.c usb_request.h composite_app.c composite_app.h usb_descriptor.c usb_descriptor.h
