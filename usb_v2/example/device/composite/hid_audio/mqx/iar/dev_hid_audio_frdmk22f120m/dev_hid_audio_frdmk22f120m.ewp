# IAR project dev_hid_audio_frdmk22f120m.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CPU_MK22F51212=1; _DEBUG=1; CPU_MK22FN512VDC12=1
  ICCARM.CCDiagSuppress: Pe223,Pe021,Pe375,Pa082
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../output/frdmk22f120m.iar/debug/usbd/mqx; ../../../../../../../../lib/frdmk22f120m.iar/debug/bsp/Generated_Code; ../../../../../../../../lib/frdmk22f120m.iar/debug/bsp/Sources; ../../../../../../../../lib/frdmk22f120m.iar/debug; ../../../../../../../../lib/frdmk22f120m.iar/debug/bsp; ../../../../../../../../lib/frdmk22f120m.iar/debug/psp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: frdmk22f120m.srec
  ILINK.IlinkOutputFile: dev_hid_audio.out
  ILINK.IlinkIcfFile: ../../../../../../../../lib/frdmk22f120m.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../output/frdmk22f120m.iar/debug/usbd/mqx/libusbd_mqx.a; ../../../../../../../../lib/frdmk22f120m.iar/debug/bsp/bsp.a; ../../../../../../../../lib/frdmk22f120m.iar/debug/psp/psp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MK22F51212=1; CPU_MK22FN512VDC12=1
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../output/frdmk22f120m.iar/release/usbd/mqx; ../../../../../../../../lib/frdmk22f120m.iar/release/bsp/Generated_Code; ../../../../../../../../lib/frdmk22f120m.iar/release/bsp/Sources; ../../../../../../../../lib/frdmk22f120m.iar/release; ../../../../../../../../lib/frdmk22f120m.iar/release/bsp; ../../../../../../../../lib/frdmk22f120m.iar/release/psp
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../../../lib/frdmk22f120m.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../output/frdmk22f120m.iar/release/usbd/mqx/libusbd_mqx.a; ../../../../../../../../lib/frdmk22f120m.iar/release/bsp/bsp.a; ../../../../../../../../lib/frdmk22f120m.iar/release/psp/psp.a
  group Sources/app
    ../../../: audio_generator.c audio_generator.h audio_data.c mouse.c mouse.h usb_request.c usb_request.h composite_app.c composite_app.h usb_descriptor.c usb_descriptor.h
