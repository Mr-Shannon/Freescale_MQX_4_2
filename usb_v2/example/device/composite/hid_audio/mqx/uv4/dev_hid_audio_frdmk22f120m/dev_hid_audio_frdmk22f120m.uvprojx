# Keil uVision project dev_hid_audio_frdmk22f120m.uvprojx, settings and files
target Int Flash Debug (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: dev_hid_audio +hex
  c flags: Optim=1 OneElfS=1
  c define: CPU_MK22F51212=1, _DEBUG=1, CPU_MK22FN512VDC12=1
  c misc: --library_interface=armcc   --library_type=standardlib  --c99  --diag_suppress=223,375
  c include: ../../..;../../../../../../../output/frdmk22f120m.uv4/debug/usbd/mqx;../../../../../../../../lib/frdmk22f120m.uv4/debug/bsp/Generated_Code;../../../../../../../../lib/frdmk22f120m.uv4/debug/bsp/Sources;../../../../../../../../lib/frdmk22f120m.uv4/debug;../../../../../../../../lib/frdmk22f120m.uv4/debug/bsp;../../../../../../../../lib/frdmk22f120m.uv4/debug/psp
  asm define: _DEBUG=1
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../../../../../lib/frdmk22f120m.uv4/debug/bsp/intflash.scf
  link misc: ../../../../../../../output/frdmk22f120m.uv4/debug/usbd/mqx/libusbd_mqx.lib

../../../../../../../../lib/frdmk22f120m.uv4/debug/bsp/bsp.lib

../../../../../../../../lib/frdmk22f120m.uv4/debug/bsp/bsp.lib(vectors.o)

../../../../../../../../lib/frdmk22f120m.uv4/debug/psp/psp.lib

../../../../../../../../lib/frdmk22f120m.uv4/debug/psp/psp.lib(linker_symbols.o)

 --keep linker_symbols.o(KERNEL_DATA_START) 

 --keep linker_symbols.o(KERNEL_DATA_END) 

 --keep linker_symbols.o(BOOT_STACK) 

 --keep vectors.o(.vectors_rom) 

 --diag_suppress=L6314W 

 --remove 

 --autoat
  group Sources/app
    ../../../: audio_generator.c audio_generator.h audio_data.c mouse.c mouse.h usb_request.c usb_request.h composite_app.c composite_app.h usb_descriptor.c usb_descriptor.h
target Int Flash Release (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.2.0
  cpu: as above
  output: dev_hid_audio +hex
  c flags: Optim=4 OneElfS=1
  c define: CPU_MK22F51212=1, CPU_MK22FN512VDC12=1
  c misc: as above
  c include: ../../..;../../../../../../../output/frdmk22f120m.uv4/release/usbd/mqx;../../../../../../../../lib/frdmk22f120m.uv4/release/bsp/Generated_Code;../../../../../../../../lib/frdmk22f120m.uv4/release/bsp/Sources;../../../../../../../../lib/frdmk22f120m.uv4/release;../../../../../../../../lib/frdmk22f120m.uv4/release/bsp;../../../../../../../../lib/frdmk22f120m.uv4/release/psp
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../../../../../lib/frdmk22f120m.uv4/release/bsp/intflash.scf
  link misc: ../../../../../../../output/frdmk22f120m.uv4/release/usbd/mqx/libusbd_mqx.lib

../../../../../../../../lib/frdmk22f120m.uv4/release/bsp/bsp.lib

../../../../../../../../lib/frdmk22f120m.uv4/release/bsp/bsp.lib(vectors.o)

../../../../../../../../lib/frdmk22f120m.uv4/release/psp/psp.lib

../../../../../../../../lib/frdmk22f120m.uv4/release/psp/psp.lib(linker_symbols.o)

 --keep linker_symbols.o(KERNEL_DATA_START) 

 --keep linker_symbols.o(KERNEL_DATA_END) 

 --keep linker_symbols.o(BOOT_STACK) 

 --keep vectors.o(.vectors_rom) 

 --diag_suppress=L6314W 

 --remove 

 --autoat
