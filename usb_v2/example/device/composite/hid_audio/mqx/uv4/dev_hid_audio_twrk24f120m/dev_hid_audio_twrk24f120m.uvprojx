# Keil uVision project dev_hid_audio_twrk24f120m.uvprojx, settings and files
target Int Flash Debug (ARM-ADS)
  device: MK24FN256xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: dev_hid_audio +hex
  c flags: Optim=1 OneElfS=1
  c define: CPU_MK24FN256VDC12=1, _DEBUG=1, CPU_MK24F25612=1
  c misc: --library_interface=armcc   --library_type=standardlib  --c99  --diag_suppress=223,375
  c include: ../../..;../../../../../../../output/twrk24f120m.uv4/debug/usbd/mqx;../../../../../../../../lib/twrk24f120m.uv4/debug/bsp/Generated_Code;../../../../../../../../lib/twrk24f120m.uv4/debug/bsp/Sources;../../../../../../../../lib/twrk24f120m.uv4/debug;../../../../../../../../lib/twrk24f120m.uv4/debug/bsp;../../../../../../../../lib/twrk24f120m.uv4/debug/psp
  asm define: _DEBUG=1
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../../../../../lib/twrk24f120m.uv4/debug/bsp/intflash.scf
  link misc: ../../../../../../../output/twrk24f120m.uv4/debug/usbd/mqx/libusbd_mqx.lib

../../../../../../../../lib/twrk24f120m.uv4/debug/bsp/bsp.lib

../../../../../../../../lib/twrk24f120m.uv4/debug/bsp/bsp.lib(vectors.o)

../../../../../../../../lib/twrk24f120m.uv4/debug/psp/psp.lib

../../../../../../../../lib/twrk24f120m.uv4/debug/psp/psp.lib(linker_symbols.o)

 --keep linker_symbols.o(KERNEL_DATA_START) 

 --keep linker_symbols.o(KERNEL_DATA_END) 

 --keep linker_symbols.o(BOOT_STACK) 

 --keep vectors.o(.vectors_rom) 

 --diag_suppress=L6314W 

 --remove 

 --autoat
  group Sources/app
    ../../../: audio_generator.c audio_generator.h audio_data.c mouse.c mouse.h usb_request.c usb_request.h composite_app.c composite_app.h usb_descriptor.c usb_descriptor.h
target Int Flash Release (ARM-ADS)
  device: MK24FN256xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.2.0
  cpu: as above
  output: dev_hid_audio +hex
  c flags: Optim=4 OneElfS=1
  c define: CPU_MK24FN256VDC12=1, CPU_MK24F25612=1
  c misc: as above
  c include: ../../..;../../../../../../../output/twrk24f120m.uv4/release/usbd/mqx;../../../../../../../../lib/twrk24f120m.uv4/release/bsp/Generated_Code;../../../../../../../../lib/twrk24f120m.uv4/release/bsp/Sources;../../../../../../../../lib/twrk24f120m.uv4/release;../../../../../../../../lib/twrk24f120m.uv4/release/bsp;../../../../../../../../lib/twrk24f120m.uv4/release/psp
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../../../../../lib/twrk24f120m.uv4/release/bsp/intflash.scf
  link misc: ../../../../../../../output/twrk24f120m.uv4/release/usbd/mqx/libusbd_mqx.lib

../../../../../../../../lib/twrk24f120m.uv4/release/bsp/bsp.lib

../../../../../../../../lib/twrk24f120m.uv4/release/bsp/bsp.lib(vectors.o)

../../../../../../../../lib/twrk24f120m.uv4/release/psp/psp.lib

../../../../../../../../lib/twrk24f120m.uv4/release/psp/psp.lib(linker_symbols.o)

 --keep linker_symbols.o(KERNEL_DATA_START) 

 --keep linker_symbols.o(KERNEL_DATA_END) 

 --keep linker_symbols.o(BOOT_STACK) 

 --keep vectors.o(.vectors_rom) 

 --diag_suppress=L6314W 

 --remove 

 --autoat
