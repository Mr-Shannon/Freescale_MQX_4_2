# IAR project otg_hid_mouse_twrk22f120m.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USBCFG_OTG=1; CPU_MK22F51212=1; _DEBUG=1; CPU_MK22FN512VDC12=1
  ICCARM.CCDiagSuppress: Pe223,Pe021,Pe375,Pa082
  ICCARM.CCIncludePath2: ../../../../../../../output/twrk22f120m.iar/debug/usbotg/mqx; ../../../../../../../../lib/twrk22f120m.iar/debug/bsp/Generated_Code; ../../../../../../../../lib/twrk22f120m.iar/debug/bsp/Sources; ../../../../../../../../lib/twrk22f120m.iar/debug; ../../../../../../../../lib/twrk22f120m.iar/debug/bsp; ../../../../../../../../lib/twrk22f120m.iar/debug/psp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: twrk22f120m.srec
  ILINK.IlinkOutputFile: otg_hid_mouse.out
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrk22f120m.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../output/twrk22f120m.iar/debug/usbotg/mqx/libusbotg_mqx.a; ../../../../../../../../lib/twrk22f120m.iar/debug/bsp/bsp.a; ../../../../../../../../lib/twrk22f120m.iar/debug/psp/psp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USBCFG_OTG=1; CPU_MK22F51212=1; CPU_MK22FN512VDC12=1
  ICCARM.CCIncludePath2: ../../../../../../../output/twrk22f120m.iar/release/usbotg/mqx; ../../../../../../../../lib/twrk22f120m.iar/release/bsp/Generated_Code; ../../../../../../../../lib/twrk22f120m.iar/release/bsp/Sources; ../../../../../../../../lib/twrk22f120m.iar/release; ../../../../../../../../lib/twrk22f120m.iar/release/bsp; ../../../../../../../../lib/twrk22f120m.iar/release/psp
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrk22f120m.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../output/twrk22f120m.iar/release/usbotg/mqx/libusbotg_mqx.a; ../../../../../../../../lib/twrk22f120m.iar/release/bsp/bsp.a; ../../../../../../../../lib/twrk22f120m.iar/release/psp/psp.a
  group Sources/app
    ../../../: dev_mouse.c host_mouse.c otg_mouse.c usb_descriptor.c
