# IAR project host_msd_fatfs_twrvf65gs10_a5.ewp, settings and files
configuration DDR Debug (ARM, debug)
  General.OGChipSelectEditMenu: VF6xx_A5 Freescale VF6xx_A5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DDR_DATA_TARGET; CPU_VF65GS10_A5=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174,Pe223
  ICCARM.CCIncludePath2: ../..; ../../mfs; ../../../../../../../output/twrvf65gs10_a5.iar/debug/usbh/mqx; ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/bsp/Generated_Code; ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/bsp/Sources; ../../../../../../../../lib/twrvf65gs10_a5.iar/debug; ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/bsp; ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/psp; ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/mfs; ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/shell
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: twrvf65gs10_a5.bin
  ILINK.IlinkOutputFile: host_msd_fatfs.out
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/bsp/ddr.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../output/twrvf65gs10_a5.iar/debug/usbh/mqx/libusbh_mqx.a; ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/bsp/bsp.a; ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/psp/psp.a; ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/mfs/mfs.a; ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/shell/shell.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration DDR Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DDR_DATA_TARGET; CPU_VF65GS10_A5=1
  ICCARM.CCIncludePath2: ../..; ../../mfs; ../../../../../../../output/twrvf65gs10_a5.iar/release/usbh/mqx; ../../../../../../../../lib/twrvf65gs10_a5.iar/release/bsp/Generated_Code; ../../../../../../../../lib/twrvf65gs10_a5.iar/release/bsp/Sources; ../../../../../../../../lib/twrvf65gs10_a5.iar/release; ../../../../../../../../lib/twrvf65gs10_a5.iar/release/bsp; ../../../../../../../../lib/twrvf65gs10_a5.iar/release/psp; ../../../../../../../../lib/twrvf65gs10_a5.iar/release/mfs; ../../../../../../../../lib/twrvf65gs10_a5.iar/release/shell
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrvf65gs10_a5.iar/release/bsp/ddr.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../output/twrvf65gs10_a5.iar/release/usbh/mqx/libusbh_mqx.a; ../../../../../../../../lib/twrvf65gs10_a5.iar/release/bsp/bsp.a; ../../../../../../../../lib/twrvf65gs10_a5.iar/release/psp/psp.a; ../../../../../../../../lib/twrvf65gs10_a5.iar/release/mfs/mfs.a; ../../../../../../../../lib/twrvf65gs10_a5.iar/release/shell/shell.a
configuration Int Ram Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SRAM_DATA_TARGET; CPU_VF65GS10_A5=1; _DEBUG=1
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/bsp/intram.icf
configuration Int Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SRAM_DATA_TARGET; CPU_VF65GS10_A5=1
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrvf65gs10_a5.iar/release/bsp/intram.icf
  ILINK.IlinkAdditionalLibs: as above
  group Sources/app
    ../../../: main.c
    ../../: command_lists.c mfs_usb.h msd_mfs_demo.c shell_task.c usb_file.c usb_file.h
  group Sources/app/mfs
    ../../mfs/: usbmfs.c usbmfs.h usbmfspr.h
