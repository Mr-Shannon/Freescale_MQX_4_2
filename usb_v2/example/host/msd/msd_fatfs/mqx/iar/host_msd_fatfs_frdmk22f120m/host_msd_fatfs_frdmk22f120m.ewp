# IAR project host_msd_fatfs_frdmk22f120m.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CPU_MK22F51212=1; _DEBUG=1; CPU_MK22FN512VDC12=1
  ICCARM.CCDiagSuppress: Pe223,Pe021,Pe375,Pa082
  ICCARM.CCIncludePath2: ../..; ../../mfs; ../../../../../../../output/frdmk22f120m.iar/debug/usbh/mqx; ../../../../../../../../lib/frdmk22f120m.iar/debug/bsp/Generated_Code; ../../../../../../../../lib/frdmk22f120m.iar/debug/bsp/Sources; ../../../../../../../../lib/frdmk22f120m.iar/debug; ../../../../../../../../lib/frdmk22f120m.iar/debug/bsp; ../../../../../../../../lib/frdmk22f120m.iar/debug/psp; ../../../../../../../../lib/frdmk22f120m.iar/debug/mfs; ../../../../../../../../lib/frdmk22f120m.iar/debug/shell
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: frdmk22f120m.srec
  ILINK.IlinkOutputFile: host_msd_fatfs.out
  ILINK.IlinkIcfFile: ../../../../../../../../lib/frdmk22f120m.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../output/frdmk22f120m.iar/debug/usbh/mqx/libusbh_mqx.a; ../../../../../../../../lib/frdmk22f120m.iar/debug/bsp/bsp.a; ../../../../../../../../lib/frdmk22f120m.iar/debug/psp/psp.a; ../../../../../../../../lib/frdmk22f120m.iar/debug/mfs/mfs.a; ../../../../../../../../lib/frdmk22f120m.iar/debug/shell/shell.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MK22F51212=1; CPU_MK22FN512VDC12=1
  ICCARM.CCIncludePath2: ../..; ../../mfs; ../../../../../../../output/frdmk22f120m.iar/release/usbh/mqx; ../../../../../../../../lib/frdmk22f120m.iar/release/bsp/Generated_Code; ../../../../../../../../lib/frdmk22f120m.iar/release/bsp/Sources; ../../../../../../../../lib/frdmk22f120m.iar/release; ../../../../../../../../lib/frdmk22f120m.iar/release/bsp; ../../../../../../../../lib/frdmk22f120m.iar/release/psp; ../../../../../../../../lib/frdmk22f120m.iar/release/mfs; ../../../../../../../../lib/frdmk22f120m.iar/release/shell
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../../../lib/frdmk22f120m.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../output/frdmk22f120m.iar/release/usbh/mqx/libusbh_mqx.a; ../../../../../../../../lib/frdmk22f120m.iar/release/bsp/bsp.a; ../../../../../../../../lib/frdmk22f120m.iar/release/psp/psp.a; ../../../../../../../../lib/frdmk22f120m.iar/release/mfs/mfs.a; ../../../../../../../../lib/frdmk22f120m.iar/release/shell/shell.a
  group Sources/app
    ../../../: main.c
    ../../: command_lists.c mfs_usb.h msd_mfs_demo.c shell_task.c usb_file.c usb_file.h
  group Sources/app/mfs
    ../../mfs/: usbmfs.c usbmfs.h usbmfspr.h
