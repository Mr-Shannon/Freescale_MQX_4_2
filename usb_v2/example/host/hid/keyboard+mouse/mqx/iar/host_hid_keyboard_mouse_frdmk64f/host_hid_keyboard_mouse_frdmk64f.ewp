# IAR project host_hid_keyboard_mouse_frdmk64f.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CPU_MK64FN1M012=1; _DEBUG=1; CPU_MK64FN1M0VMD12=1
  ICCARM.CCDiagSuppress: Pe223,Pe021,Pe375,Pa082
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../output/frdmk64f.iar/debug/usbh/mqx; ../../../../../../../../lib/frdmk64f.iar/debug/bsp/Generated_Code; ../../../../../../../../lib/frdmk64f.iar/debug/bsp/Sources; ../../../../../../../../lib/frdmk64f.iar/debug; ../../../../../../../../lib/frdmk64f.iar/debug/bsp; ../../../../../../../../lib/frdmk64f.iar/debug/psp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: twrk22f120m.srec
  ILINK.IlinkOutputFile: host_hid_keyboard_mouse.out
  ILINK.IlinkIcfFile: ../../../../../../../../lib/frdmk64f.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../output/frdmk64f.iar/debug/usbh/mqx/libusbh_mqx.a; ../../../../../../../../lib/frdmk64f.iar/debug/bsp/bsp.a; ../../../../../../../../lib/frdmk64f.iar/debug/psp/psp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MK64FN1M012=1; CPU_MK64FN1M0VMD12=1
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../output/frdmk64f.iar/release/usbh/mqx; ../../../../../../../../lib/frdmk64f.iar/release/bsp/Generated_Code; ../../../../../../../../lib/frdmk64f.iar/release/bsp/Sources; ../../../../../../../../lib/frdmk64f.iar/release; ../../../../../../../../lib/frdmk64f.iar/release/bsp; ../../../../../../../../lib/frdmk64f.iar/release/psp
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../../../lib/frdmk64f.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../output/frdmk64f.iar/release/usbh/mqx/libusbh_mqx.a; ../../../../../../../../lib/frdmk64f.iar/release/bsp/bsp.a; ../../../../../../../../lib/frdmk64f.iar/release/psp/psp.a
  group Sources/app
    ../../../: hidmouse.c hidmouse.h hidkeyboard.c hidkeyboard.h mouse_keyboard.c mouse_keyboard.h
