# Keil uVision project usbotg_mqx_twrk65f180m.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MK65FN2M0xxx18 Freescale
  pack: Keil.Kinetis_K60_DFP.1.3.0
  cpu: IROM(0x00000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: libusbotg_mqx (library)
  AfterMake: "../../../../../usb_core/otg/build/bat/usbotg_twrk65f180m.bat" "../../../../.." "../../../../../output/twrk65f180m.uv4/debug/usbotg/mqx" uv4 mqx & ".copy.bat" "Debug/libusbotg_mqx.lib" "../../../../../output/twrk65f180m.uv4/debug/usbotg/mqx/libusbotg_mqx.lib"
  c flags: Optim=1 OneElfS=1
  c define: CPU_MK65F18=1, USBCFG_OTG=1, CPU_MK65FN2M0VMI18=1, _DEBUG=1
  c misc: --library_interface=armcc   --library_type=standardlib  --c99  --diag_suppress=223,375
  c include: ../../../../../adapter/sources;../../../../../adapter/sources/mqx;../../../../hal;../../../../device/include/twrk65f180m;../../../../device/include;../../../../device/sources/classes/audio;../../../../device/sources/classes/include/config;../../../../device/sources/classes/cdc;../../../../device/sources/classes/common;../../../../device/sources/classes/composite;../../../../device/sources/classes/hid;../../../../device/sources/classes/include;../../../../device/sources/classes/msd;../../../../device/sources/classes/phdc;../../../../device/sources/controller;../../../../device/sources/controller/ehci;../../../../device/sources/controller/khci;../../../../host/sources/classes/audio;../../../../host/sources/classes/cdc;../../../../host/sources/classes/hid;../../../../host/sources/classes/hub;../../../../host/sources/classes/msd;../../../../host/sources/classes/phdc;../../../../host/sources/controller;../../../../host/sources/controller/ehci;../../../../host/sources/controller/khci;../../../../host/include/twrk65f180m;../../../../host/include;../../../../include;../../../sources/include;../../../sources/driver;../../../sources/driver/khci;../../../sources/driver/max3353;../../../sources/otg;../../../../../../lib/twrk65f180m.uv4/debug/bsp/Generated_Code;../../../../../../lib/twrk65f180m.uv4/debug/bsp/Sources;../../../../../../lib/twrk65f180m.uv4/debug;../../../../../../lib/twrk65f180m.uv4/debug/bsp;../../../../../../lib/twrk65f180m.uv4/debug/psp
  asm define: _DEBUG=1
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ..\..\..\lib\twrk65f180m.uv4\mqx\intflash.scf
  group adapter
    ../../../../../adapter/sources/: adapter.h adapter_types.h
    ../../../../../adapter/sources/mqx/: adapter_mqx.c adapter_mqx.h adapter_cfg.h
  group hal
    ../../../../hal/: fsl_usb_khci_hal.h
  group usb_core/device/include
    ../../../../device/include/twrk65f180m/: usb_device_config.h
    ../../../../device/include/: usb_device_stack_interface.h
  group usb_core/device/sources/bsp
    ../../../../device/sources/bsp/twrk65f180m/: usb_dev_bsp.c
  group usb_core/device/sources/class driver/audio
    ../../../../device/sources/classes/audio/: usb_audio.c usb_audio.h
    ../../../../device/sources/classes/include/config/: usb_audio_config.h
  group usb_core/device/sources/class driver/cdc
    ../../../../device/sources/classes/cdc/: usb_cdc_pstn.c usb_cdc_pstn.h usb_cdc.c usb_cdc.h
    ../../../../device/sources/classes/include/config/: usb_cdc_config.h
  group usb_core/device/sources/class driver/common
    ../../../../device/sources/classes/common/: usb_class.c usb_class_internal.h
  group usb_core/device/sources/class driver/composite
    ../../../../device/sources/classes/composite/: usb_composite.c usb_composite.h
    ../../../../device/sources/classes/include/config/: usb_composite_config.h
  group usb_core/device/sources/class driver/hid
    ../../../../device/sources/classes/hid/: usb_hid.c usb_hid.h
    ../../../../device/sources/classes/include/config/: usb_hid_config.h
  group usb_core/device/sources/class driver/include
    ../../../../device/sources/classes/include/: usb_class_audio.h usb_class_cdc.h usb_class_composite.h usb_class_hid.h usb_class_msc.h usb_class_phdc.h usb_class.h
  group usb_core/device/sources/class driver/msd
    ../../../../device/sources/classes/msd/: usb_msc_scsi.c usb_msc_scsi.h usb_msc.c usb_msc.h
    ../../../../device/sources/classes/include/config/: usb_msc_config.h
  group usb_core/device/sources/class driver/phdc
    ../../../../device/sources/classes/phdc/: usb_phdc.c usb_phdc.h
    ../../../../device/sources/classes/include/config/: usb_phdc_config.h
  group usb_core/device/sources/controller driver
    ../../../../device/sources/controller/: usb_dev.c usb_dev.h usb_framework.c usb_framework.h
  group usb_core/device/sources/controller driver/ehci
    ../../../../device/sources/controller/ehci/: ehci_dev_main.h ehci_dev_main.c device_ehci_interface.c ehci_usbprv.h
  group usb_core/device/sources/controller driver/khci
    ../../../../device/sources/controller/khci/: khci_dev_misc.h khci_dev.c khci_dev.h device_khci_interface.c
  group usb_core/host/sources/class driver/audio
    ../../../../host/sources/classes/audio/: usb_host_audio.c usb_host_audio_intf.c usb_host_audio.h
  group usb_core/host/sources/class driver/cdc
    ../../../../host/sources/classes/cdc/: usb_host_cdc.c usb_host_cdc_intf.c usb_host_cdc.h
  group usb_core/host/sources/class driver/common
    ../../../../host/sources/classes/common/: usb_classes.c
  group usb_core/host/sources/class driver/hid
    ../../../../host/sources/classes/hid/: usb_host_hid.c usb_host_hid.h
  group usb_core/host/sources/class driver/hub
    ../../../../host/sources/classes/hub/: usb_host_hub_prv.h usb_host_hub_sm.c usb_host_hub_sm.h usb_host_hub.c usb_host_hub.h
  group usb_core/host/sources/class driver/msd
    ../../../../host/sources/classes/msd/: usb_host_msd_bo.c usb_host_msd_bo.h usb_host_msd_queue.c usb_host_msd_ufi.c usb_host_msd_ufi.h
  group usb_core/host/sources/class driver/phdc
    ../../../../host/sources/classes/phdc/: usb_host_phdc.c usb_host_phdc.h
  group usb_core/host/sources/controller driver
    ../../../../host/sources/controller/: usb_host_ch9.c usb_host_ch9.h usb_host_common.c usb_host_common.h usb_host_dev_mng.c usb_host_dev_mng.h usb_host.c usb_host.h
  group usb_core/host/sources/controller driver/ehci
    ../../../../host/sources/controller/ehci/: ehci_host.c host_ehci_interface.c ehci.h ehci_prv.h
  group usb_core/host/sources/controller driver/khci
    ../../../../host/sources/controller/khci/: khci.c host_khci_interface.c khci.h khci_prv.h
  group usb_core/host/include
    ../../../../host/include/twrk65f180m/: usb_host_config.h
    ../../../../host/include/: usb_host_stack_interface.h
  group usb_core/host/sources/bsp
    ../../../../host/sources/bsp/twrk65f180m/: usb_host_bsp.c
  group usb_core/include
    ../../../../include/: compiler.h types.h usb_desc.h usb_error.h usb_misc.h usb_opt.h usb_types.h
  group usb_core/otg/include
    ../../../sources/include/: usb_otg_dev_api.h usb_otg_host_api.h usb_otg_main.h
  group usb_core/otg/sources/bsp
    ../../../sources/bsp/twrk65f180m/: usb_otg_bsp.c
  group usb_core/otg/sources/driver
    ../../../sources/driver/: usb_otg.c usb_otg.h
  group usb_core/otg/sources/driver/khci
    ../../../sources/driver/khci/: usb_otg_khci.c usb_otg_khci.h
  group usb_core/otg/sources/driver/max3353
    ../../../sources/driver/max3353/mqx/: usb_otg_max3353.c
    ../../../sources/driver/max3353/: max3353_interface.c usb_otg_max3353.h
  group usb_core/otg/sources/otg
    ../../../sources/otg/: usb_otg_main.c usb_otg_private.h usb_otg_sm.h usb_otg_sm_a.c usb_otg_sm_b.c usb_otg_sm_main.c
target Release (ARM-ADS)
  device: MK65FN2M0xxx18 Freescale
  pack: Keil.Kinetis_K60_DFP.1.3.0
  cpu: as above
  output: libusbotg_mqx (library)
  AfterMake: "../../../../../usb_core/otg/build/bat/usbotg_twrk65f180m.bat" "../../../../.." "../../../../../output/twrk65f180m.uv4/release/usbotg/mqx" uv4 mqx & ".copy.bat" "Release/libusbotg_mqx.lib" "../../../../../output/twrk65f180m.uv4/release/usbotg/mqx/libusbotg_mqx.lib"
  c flags: Optim=4 OneElfS=1
  c define: USBCFG_OTG=1, CPU_MK65F18=1, CPU_MK65FN2M0VMI18=1
  c misc: as above
  c include: ../../../../../adapter/sources;../../../../../adapter/sources/mqx;../../../../hal;../../../../device/include/twrk65f180m;../../../../device/include;../../../../device/sources/classes/audio;../../../../device/sources/classes/include/config;../../../../device/sources/classes/cdc;../../../../device/sources/classes/common;../../../../device/sources/classes/composite;../../../../device/sources/classes/hid;../../../../device/sources/classes/include;../../../../device/sources/classes/msd;../../../../device/sources/classes/phdc;../../../../device/sources/controller;../../../../device/sources/controller/ehci;../../../../device/sources/controller/khci;../../../../host/sources/classes/audio;../../../../host/sources/classes/cdc;../../../../host/sources/classes/hid;../../../../host/sources/classes/hub;../../../../host/sources/classes/msd;../../../../host/sources/classes/phdc;../../../../host/sources/controller;../../../../host/sources/controller/ehci;../../../../host/sources/controller/khci;../../../../host/include/twrk65f180m;../../../../host/include;../../../../include;../../../sources/include;../../../sources/driver;../../../sources/driver/khci;../../../sources/driver/max3353;../../../sources/otg;../../../../../../lib/twrk65f180m.uv4/release/bsp/Generated_Code;../../../../../../lib/twrk65f180m.uv4/release/bsp/Sources;../../../../../../lib/twrk65f180m.uv4/release;../../../../../../lib/twrk65f180m.uv4/release/bsp;../../../../../../lib/twrk65f180m.uv4/release/psp
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ..\..\..\lib\twrk65f180m.uv4\mqx\intflash.scf
