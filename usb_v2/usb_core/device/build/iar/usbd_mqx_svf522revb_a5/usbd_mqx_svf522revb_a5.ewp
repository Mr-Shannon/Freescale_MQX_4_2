# IAR project usbd_mqx_svf522revb_a5.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: VF6xx_A5 Freescale VF6xx_A5
  ICCARM.CCDefines: _DEBUG=1; CPU_SVF522R3K_A5=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174,Pe223
  ICCARM.CCIncludePath2: ../../../../../adapter/sources; ../../../../../adapter/sources/mqx; ../../../../hal; ../../../include/svf522revb_a5; ../../../include; ../../../sources/classes/audio; ../../../sources/classes/include/config; ../../../sources/classes/cdc; ../../../sources/classes/common; ../../../sources/classes/composite; ../../../sources/classes/hid; ../../../sources/classes/include; ../../../sources/classes/msd; ../../../sources/classes/phdc; ../../../sources/controller; ../../../sources/controller/ehci; ../../../sources/controller/khci; ../../../../include; ../../../../../../lib/svf522revb_a5.iar/debug/bsp/Generated_Code; ../../../../../../lib/svf522revb_a5.iar/debug/bsp/Sources; ../../../../../../lib/svf522revb_a5.iar/debug; ../../../../../../lib/svf522revb_a5.iar/debug/bsp; ../../../../../../lib/svf522revb_a5.iar/debug/psp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  postbuild: "../../../../../usb_core/device/build/bat/usbd_svf522revb_a5.bat" "../../../../.." "../../../../../output/svf522revb_a5.iar/debug/usbd/mqx" iar mqx
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_SVF522R3K_A5=1
  ICCARM.CCIncludePath2: ../../../../../adapter/sources; ../../../../../adapter/sources/mqx; ../../../../hal; ../../../include/svf522revb_a5; ../../../include; ../../../sources/classes/audio; ../../../sources/classes/include/config; ../../../sources/classes/cdc; ../../../sources/classes/common; ../../../sources/classes/composite; ../../../sources/classes/hid; ../../../sources/classes/include; ../../../sources/classes/msd; ../../../sources/classes/phdc; ../../../sources/controller; ../../../sources/controller/ehci; ../../../sources/controller/khci; ../../../../include; ../../../../../../lib/svf522revb_a5.iar/release/bsp/Generated_Code; ../../../../../../lib/svf522revb_a5.iar/release/bsp/Sources; ../../../../../../lib/svf522revb_a5.iar/release; ../../../../../../lib/svf522revb_a5.iar/release/bsp; ../../../../../../lib/svf522revb_a5.iar/release/psp
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  postbuild: "../../../../../usb_core/device/build/bat/usbd_svf522revb_a5.bat" "../../../../.." "../../../../../output/svf522revb_a5.iar/release/usbd/mqx" iar mqx
  ILINK.IlinkOutputFile: libgeneric.out
  group adapter
    ../../../../../adapter/sources/: adapter.h adapter_types.h
    ../../../../../adapter/sources/mqx/: adapter_mqx.c adapter_mqx.h adapter_cfg.h
  group hal
    ../../../../hal/: fsl_usb_ehci_hal.h fsl_usb_khci_hal.h
  group usb_core/device/include
    ../../../include/svf522revb_a5/: usb_device_config.h
    ../../../include/: usb_device_stack_interface.h
  group usb_core/device/sources/bsp
    ../../../sources/bsp/svf522revb_a5/: usb_dev_bsp.c
  group usb_core/device/sources/class driver/audio
    ../../../sources/classes/audio/: usb_audio.c usb_audio.h
    ../../../sources/classes/include/config/: usb_audio_config.h
  group usb_core/device/sources/class driver/cdc
    ../../../sources/classes/cdc/: usb_cdc_pstn.c usb_cdc_pstn.h usb_cdc.c usb_cdc.h
    ../../../sources/classes/include/config/: usb_cdc_config.h
  group usb_core/device/sources/class driver/common
    ../../../sources/classes/common/: usb_class.c usb_class_internal.h
  group usb_core/device/sources/class driver/composite
    ../../../sources/classes/composite/: usb_composite.c usb_composite.h
    ../../../sources/classes/include/config/: usb_composite_config.h
  group usb_core/device/sources/class driver/hid
    ../../../sources/classes/hid/: usb_hid.c usb_hid.h
    ../../../sources/classes/include/config/: usb_hid_config.h
  group usb_core/device/sources/class driver/include
    ../../../sources/classes/include/: usb_class_audio.h usb_class_cdc.h usb_class_composite.h usb_class_hid.h usb_class_msc.h usb_class_phdc.h usb_class.h
  group usb_core/device/sources/class driver/msd
    ../../../sources/classes/msd/: usb_msc_scsi.c usb_msc_scsi.h usb_msc.c usb_msc.h
    ../../../sources/classes/include/config/: usb_msc_config.h
  group usb_core/device/sources/class driver/phdc
    ../../../sources/classes/phdc/: usb_phdc.c usb_phdc.h
    ../../../sources/classes/include/config/: usb_phdc_config.h
  group usb_core/device/sources/controller driver
    ../../../sources/controller/: usb_dev.c usb_dev.h usb_framework.c usb_framework.h
  group usb_core/device/sources/controller driver/ehci
    ../../../sources/controller/ehci/: ehci_usbprv.h ehci_dev_main.c ehci_dev_main.h device_ehci_interface.c
  group usb_core/device/sources/controller driver/khci
    ../../../sources/controller/khci/: khci_dev_misc.h khci_dev.c khci_dev.h device_khci_interface.c
  group usb_core/include
    ../../../../include/: compiler.h types.h usb_desc.h usb_error.h usb_misc.h usb_opt.h usb_types.h
