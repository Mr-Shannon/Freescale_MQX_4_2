# IAR project usbh_mqx_twrk65f180m.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: CPU_MK65F18=1; CPU_MK65FN2M0VMI18=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pe223,Pe021,Pe375,Pa082
  ICCARM.CCIncludePath2: ../../../../../adapter/sources; ../../../../../adapter/sources/mqx; ../../../../hal; ../../../sources/classes/audio; ../../../sources/classes/cdc; ../../../sources/classes/hid; ../../../sources/classes/hub; ../../../sources/classes/msd; ../../../sources/classes/phdc; ../../../sources/controller; ../../../sources/controller/ehci; ../../../sources/controller/khci; ../../../include/twrk65f180m; ../../../include; ../../../../include; ../../../../../../lib/twrk65f180m.iar/debug/bsp/Generated_Code; ../../../../../../lib/twrk65f180m.iar/debug/bsp/Sources; ../../../../../../lib/twrk65f180m.iar/debug; ../../../../../../lib/twrk65f180m.iar/debug/bsp; ../../../../../../lib/twrk65f180m.iar/debug/psp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  postbuild: "../../../../../usb_core/host/build/bat/usbh_twrk65f180m.bat" "../../../../.." "../../../../../output/twrk65f180m.iar/debug/usbh/mqx" iar mqx
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MK65F18=1; CPU_MK65FN2M0VMI18=1
  ICCARM.CCIncludePath2: ../../../../../adapter/sources; ../../../../../adapter/sources/mqx; ../../../../hal; ../../../sources/classes/audio; ../../../sources/classes/cdc; ../../../sources/classes/hid; ../../../sources/classes/hub; ../../../sources/classes/msd; ../../../sources/classes/phdc; ../../../sources/controller; ../../../sources/controller/ehci; ../../../sources/controller/khci; ../../../include/twrk65f180m; ../../../include; ../../../../include; ../../../../../../lib/twrk65f180m.iar/release/bsp/Generated_Code; ../../../../../../lib/twrk65f180m.iar/release/bsp/Sources; ../../../../../../lib/twrk65f180m.iar/release; ../../../../../../lib/twrk65f180m.iar/release/bsp; ../../../../../../lib/twrk65f180m.iar/release/psp
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  postbuild: "../../../../../usb_core/host/build/bat/usbh_twrk65f180m.bat" "../../../../.." "../../../../../output/twrk65f180m.iar/release/usbh/mqx" iar mqx
  ILINK.IlinkOutputFile: libgeneric.out
  group adapter
    ../../../../../adapter/sources/: adapter.h adapter_types.h
    ../../../../../adapter/sources/mqx/: adapter_mqx.c adapter_mqx.h adapter_cfg.h
  group hal
    ../../../../hal/: fsl_usb_khci_hal.h
  group usb_core/host/sources/class driver/audio
    ../../../sources/classes/audio/: usb_host_audio.c usb_host_audio_intf.c usb_host_audio.h
  group usb_core/host/sources/class driver/cdc
    ../../../sources/classes/cdc/: usb_host_cdc.c usb_host_cdc_intf.c usb_host_cdc.h
  group usb_core/host/sources/class driver/common
    ../../../sources/classes/common/: usb_classes.c
  group usb_core/host/sources/class driver/hid
    ../../../sources/classes/hid/: usb_host_hid.c usb_host_hid.h
  group usb_core/host/sources/class driver/hub
    ../../../sources/classes/hub/: usb_host_hub_prv.h usb_host_hub_sm.c usb_host_hub_sm.h usb_host_hub.c usb_host_hub.h
  group usb_core/host/sources/class driver/msd
    ../../../sources/classes/msd/: usb_host_msd_bo.c usb_host_msd_bo.h usb_host_msd_queue.c usb_host_msd_ufi.c usb_host_msd_ufi.h
  group usb_core/host/sources/class driver/phdc
    ../../../sources/classes/phdc/: usb_host_phdc.c usb_host_phdc.h
  group usb_core/host/sources/controller driver
    ../../../sources/controller/: usb_host_ch9.c usb_host_ch9.h usb_host_common.c usb_host_common.h usb_host_dev_mng.c usb_host_dev_mng.h usb_host.c usb_host.h
  group usb_core/host/sources/controller driver/ehci
    ../../../sources/controller/ehci/: ehci_host.c ehci.h ehci_prv.h host_ehci_interface.c
  group usb_core/host/sources/controller driver/khci
    ../../../sources/controller/khci/: khci.c host_khci_interface.c khci.h khci_prv.h
  group usb_core/host/sources/bsp
    ../../../sources/bsp/twrk65f180m/: usb_host_bsp.c
  group usb_core/host/include
    ../../../include/twrk65f180m/: usb_host_config.h
    ../../../include/: usb_host_stack_interface.h
  group usb_core/include
    ../../../../include/: compiler.h types.h usb_desc.h usb_error.h usb_misc.h usb_opt.h usb_types.h
