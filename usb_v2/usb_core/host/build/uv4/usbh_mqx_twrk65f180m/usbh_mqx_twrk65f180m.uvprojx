# Keil uVision project usbh_mqx_twrk65f180m.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MK65FN2M0xxx18 Freescale
  pack: Keil.Kinetis_K60_DFP.1.3.0
  cpu: IROM(0x00000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: libusbh_mqx (library)
  AfterMake: "../../../../../usb_core/host/build/bat/usbh_twrk65f180m.bat" "../../../../.." "../../../../../output/twrk65f180m.uv4/debug/usbh/mqx" uv4 mqx & ".copy.bat" "Debug/libusbh_mqx.lib" "../../../../../output/twrk65f180m.uv4/debug/usbh/mqx/libusbh_mqx.lib"
  c flags: Optim=1 OneElfS=1
  c define: CPU_MK65F18=1, CPU_MK65FN2M0VMI18=1, _DEBUG=1
  c misc: --library_interface=armcc   --library_type=standardlib  --c99  --diag_suppress=223,375
  c include: ../../../../../adapter/sources;../../../../../adapter/sources/mqx;../../../../hal;../../../sources/classes/audio;../../../sources/classes/cdc;../../../sources/classes/hid;../../../sources/classes/hub;../../../sources/classes/msd;../../../sources/classes/phdc;../../../sources/controller;../../../sources/controller/ehci;../../../sources/controller/khci;../../../include/twrk65f180m;../../../include;../../../../include;../../../../../../lib/twrk65f180m.uv4/debug/bsp/Generated_Code;../../../../../../lib/twrk65f180m.uv4/debug/bsp/Sources;../../../../../../lib/twrk65f180m.uv4/debug;../../../../../../lib/twrk65f180m.uv4/debug/bsp;../../../../../../lib/twrk65f180m.uv4/debug/psp
  asm define: _DEBUG=1
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ..\..\..\lib\twrk65f180m.uv4\mqx\intflash.scf
  group adapter
    ../../../../../adapter/sources/: adapter.h adapter_types.h
    ../../../../../adapter/sources/mqx/: adapter_mqx.c adapter_mqx.h adapter_cfg.h
  group hal
    ../../../../hal/: fsl_usb_khci_hal.h
  group usb_core/host/sources/class driver/audio
    ../../../sources/classes/audio/: usb_host_audio.c usb_host_audio_intf.c usb_host_audio.h
  group usb_core/host/sources/class driver/cdc
    ../../../sources/classes/cdc/: usb_host_cdc.c usb_host_cdc_intf.c usb_host_cdc.h
  group usb_core/host/sources/class driver/common
    ../../../sources/classes/common/: usb_classes.c
  group usb_core/host/sources/class driver/hid
    ../../../sources/classes/hid/: usb_host_hid.c usb_host_hid.h
  group usb_core/host/sources/class driver/hub
    ../../../sources/classes/hub/: usb_host_hub_prv.h usb_host_hub_sm.c usb_host_hub_sm.h usb_host_hub.c usb_host_hub.h
  group usb_core/host/sources/class driver/msd
    ../../../sources/classes/msd/: usb_host_msd_bo.c usb_host_msd_bo.h usb_host_msd_queue.c usb_host_msd_ufi.c usb_host_msd_ufi.h
  group usb_core/host/sources/class driver/phdc
    ../../../sources/classes/phdc/: usb_host_phdc.c usb_host_phdc.h
  group usb_core/host/sources/controller driver
    ../../../sources/controller/: usb_host_ch9.c usb_host_ch9.h usb_host_common.c usb_host_common.h usb_host_dev_mng.c usb_host_dev_mng.h usb_host.c usb_host.h
  group usb_core/host/sources/controller driver/ehci
    ../../../sources/controller/ehci/: ehci_host.c ehci.h ehci_prv.h host_ehci_interface.c
  group usb_core/host/sources/controller driver/khci
    ../../../sources/controller/khci/: khci.c host_khci_interface.c khci.h khci_prv.h
  group usb_core/host/include
    ../../../include/twrk65f180m/: usb_host_config.h
    ../../../include/: usb_host_stack_interface.h
  group usb_core/host/sources/bsp
    ../../../sources/bsp/twrk65f180m/: usb_host_bsp.c
  group usb_core/include
    ../../../../include/: compiler.h types.h usb_desc.h usb_error.h usb_misc.h usb_opt.h usb_types.h
target Release (ARM-ADS)
  device: MK65FN2M0xxx18 Freescale
  pack: Keil.Kinetis_K60_DFP.1.3.0
  cpu: as above
  output: libusbh_mqx (library)
  AfterMake: "../../../../../usb_core/host/build/bat/usbh_twrk65f180m.bat" "../../../../.." "../../../../../output/twrk65f180m.uv4/release/usbh/mqx" uv4 mqx & ".copy.bat" "Release/libusbh_mqx.lib" "../../../../../output/twrk65f180m.uv4/release/usbh/mqx/libusbh_mqx.lib"
  c flags: Optim=4 OneElfS=1
  c define: CPU_MK65F18=1, CPU_MK65FN2M0VMI18=1
  c misc: as above
  c include: ../../../../../adapter/sources;../../../../../adapter/sources/mqx;../../../../hal;../../../sources/classes/audio;../../../sources/classes/cdc;../../../sources/classes/hid;../../../sources/classes/hub;../../../sources/classes/msd;../../../sources/classes/phdc;../../../sources/controller;../../../sources/controller/ehci;../../../sources/controller/khci;../../../include/twrk65f180m;../../../include;../../../../include;../../../../../../lib/twrk65f180m.uv4/release/bsp/Generated_Code;../../../../../../lib/twrk65f180m.uv4/release/bsp/Sources;../../../../../../lib/twrk65f180m.uv4/release;../../../../../../lib/twrk65f180m.uv4/release/bsp;../../../../../../lib/twrk65f180m.uv4/release/psp
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ..\..\..\lib\twrk65f180m.uv4\mqx\intflash.scf
