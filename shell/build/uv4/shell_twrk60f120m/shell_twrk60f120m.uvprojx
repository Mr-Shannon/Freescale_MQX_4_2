# Keil uVision project shell_twrk60f120m.uvprojx, settings and files
target debug (ARM-ADS)
  device: MK60FN1M0xxx12 Freescale Semiconductor
  cpu: CPUTYPE("Cortex-M4.fp")
  output: shell.lib (library)
  AfterMake: ../../bat/shell_twrk60f120m.bat ../../../.. ../../../../lib/twrk60f120m.uv4/debug/shell uv4
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: -J../../../source/include 
-J../../../source/include 
-J../../../source/include 
-J../../../../mqx/source/io/adc/kadc 
-J../../../../mqx/source/io/adc 
-J../../../../mqx/source/io/cm 
-J../../../../config/twrk60f120m 
-J../../../../mqx/source/io/dma 
-J../../../../mqx/source/io/enet/macnet 
-J../../../../mqx/source/io/enet/phy 
-J../../../../mqx/source/io/enet 
-J../../../../mqx/source/io/esdhc 
-J../../../../mqx/source/io/flashx/freescale 
-J../../../../mqx/source/io/flashx 
-J../../../../mqx/source/io/flashx/amd 
-J../../../../mqx/source/io/flashx/fujitsu 
-J../../../../mqx/source/io/flashx/spansion 
-J../../../../mqx/source/io/flashx/atmel 
-J../../../../mqx/source/io/flashx/istrata 
-J../../../../mqx/source/io/flashx/sharp 
-J../../../../mqx/source/io/can/flexcan 
-J../../../../mqx/source/io/gpio/kgpio 
-J../../../../mqx/source/io/gpio 
-J../../../../mqx/source/io/hwtimer 
-J../../../../mqx/source/io/i2c 
-J../../../../mqx/source/io/i2c/polled 
-J../../../../mqx/source/io/i2c/int 
-J../../../../mqx/source/bsp/twrk60f120m 
-J../../../../config/common 
-J../../../../mqx/source/include 
-J../../../../mqx/source/bsp/twrk60f120m 
-J../../../../mqx/source/io/enet 
-J../../../../mqx/source/io/debug 
-J../../../../mqx/source/io/io_mem 
-J../../../../mqx/source/io/io_null 
-J../../../../mqx/source/io/pipe 
-J../../../../mqx/source/io/lpm 
-J../../../../mqx/source/io/lwadc 
-J../../../../mqx/source/io/lwgpio 
-J../../../../mqx/source/io/nandflash/nfc 
-J../../../../mqx/source/io/nandflash 
-J../../../../mqx/source/io/pcb 
-J../../../../mqx/source/io/pcb/mqxa 
-J../../../../mqx/source/io/pccard 
-J../../../../mqx/source/io/pcflash 
-J../../../../mqx/source/io/rtc 
-J../../../../mqx/source/io/sai 
-J../../../../mqx/source/io/sai/dma 
-J../../../../mqx/source/io/sdcard/sdcard_esdhc 
-J../../../../mqx/source/io/sdcard/sdcard_spi 
-J../../../../mqx/source/io/sdcard 
-J../../../../mqx/source/io/serial 
-J../../../../mqx/source/io/spi 
-J../../../../mqx/source/io/tchres 
-J../../../../mqx/source/io/tfs 
-J../../../../mqx/source/io/timer 
-J../../../../mqx/source/io/usb 
-J../../../../mqx/source/io/usb_dcd 
-J../../../../mqx/source/io/usb_dcd/polled 
-J../../../../mqx/source/io/usb_dcd/int 
-J../../../../mqx/source/psp/cortex_m/compiler/rv_uv4 
-J../../../../mqx/source/psp/cortex_m/cpu 
-J../../../../mqx/source/psp/cortex_m 
-J../../../../config/twrk60f120m 
-J../../../../config/common 
-J../../../../mqx/source/include 
-J../../../../mqx/source/tad 
-J../../../../mfs/source/include 
-J../../../../rtcs/source/include 
-J../../../../ssl 
-J#J 
--library_interface=none 
--library_type=standardlib 
--c99 
--diag_suppress=1296,186
  c include: ../../../source/include;../../../source/include;../../../source/include;../../../../mqx/source/io/adc/kadc;../../../../mqx/source/io/adc;../../../../mqx/source/io/cm;../../../../config/twrk60f120m;../../../../mqx/source/io/dma;../../../../mqx/source/io/enet/macnet;../../../../mqx/source/io/enet/phy;../../../../mqx/source/io/enet;../../../../mqx/source/io/esdhc;../../../../mqx/source/io/flashx/freescale;../../../../mqx/source/io/flashx;../../../../mqx/source/io/flashx/amd;../../../../mqx/source/io/flashx/fujitsu;../../../../mqx/source/io/flashx/spansion;../../../../mqx/source/io/flashx/atmel;../../../../mqx/source/io/flashx/istrata;../../../../mqx/source/io/flashx/sharp;../../../../mqx/source/io/can/flexcan;../../../../mqx/source/io/gpio/kgpio;../../../../mqx/source/io/gpio;../../../../mqx/source/io/hwtimer;../../../../mqx/source/io/i2c;../../../../mqx/source/io/i2c/polled;../../../../mqx/source/io/i2c/int;../../../../mqx/source/bsp/twrk60f120m;../../../../config/common;../../../../mqx/source/include;../../../../mqx/source/bsp/twrk60f120m;../../../../mqx/source/io/enet;../../../../mqx/source/io/debug;../../../../mqx/source/io/io_mem;../../../../mqx/source/io/io_null;../../../../mqx/source/io/pipe;../../../../mqx/source/io/lpm;../../../../mqx/source/io/lwadc;../../../../mqx/source/io/lwgpio;../../../../mqx/source/io/nandflash/nfc;../../../../mqx/source/io/nandflash;../../../../mqx/source/io/pcb;../../../../mqx/source/io/pcb/mqxa;../../../../mqx/source/io/pccard;../../../../mqx/source/io/pcflash;../../../../mqx/source/io/rtc;../../../../mqx/source/io/sai;../../../../mqx/source/io/sai/dma;../../../../mqx/source/io/sdcard/sdcard_esdhc;../../../../mqx/source/io/sdcard/sdcard_spi;../../../../mqx/source/io/sdcard;../../../../mqx/source/io/serial;../../../../mqx/source/io/spi;../../../../mqx/source/io/tchres;../../../../mqx/source/io/tfs;../../../../mqx/source/io/timer;../../../../mqx/source/io/usb;../../../../mqx/source/io/usb_dcd;../../../../mqx/source/io/usb_dcd/polled;../../../../mqx/source/io/usb_dcd/int;../../../../mqx/source/psp/cortex_m/compiler/rv_uv4;../../../../mqx/source/psp/cortex_m/cpu;../../../../mqx/source/psp/cortex_m;../../../../config/twrk60f120m;../../../../config/common;../../../../mqx/source/include;../../../../mqx/source/tad;../../../../mfs/source/include;../../../../rtcs/source/include;../../../../ssl
  asm misc: --cpreproc_opts '-D_DEBUG=1' --cpreproc
  asm include: ../../../../mqx/source/io/debug;../../../../mqx/source/psp/cortex_m/compiler/rv_uv4;../../../../mqx/source/psp/cortex_m;../../../../mqx/source/psp/cortex_m/core/M4;../../../../config/twrk60f120m;../../../../mqx/source/include;../../../../config/common
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk60f120m.uv4\mqx\intflash.scf
  group Shell Source/mfs
    ../../../source/mfs/: sh_cache.c sh_cd.c sh_compare.c sh_copy.c sh_create.c sh_del.c sh_df.c sh_di.c sh_dir.c sh_dirent.c sh_disect.c sh_flush.c sh_format.c sh_mkdir.c sh_pwd.c sh_read.c sh_readtest.c sh_rename.c sh_rmdir.c sh_type.c sh_write.c sh_writetest.c
    ../../../source/include/: sh_mfs.h
  group Shell Source/mqx
    ../../../source/mqx/: sh_abort.c sh_kill.c sh_pause.c sh_tad.c
    ../../../source/include/: sh_prv.h shell.h
  group Shell Source/rtcs
    ../../../source/rtcs/: sh_arpdisp.c sh_clock.c sh_echo.c sh_echosrv.c sh_enet.c sh_ftpc.c sh_ftpsrv.c sh_gate.c sh_getroute.c sh_ghbn.c sh_getname.c sh_ipconfig.c sh_iwconfig.c sh_llmnrsrv.c sh_nat.c sh_nstat.c sh_ping.c sh_ppp.c sh_rtcs.c sh_sendto.c sh_smtp.c sh_snmpd.c sh_tftpcln.c sh_tftpsrv.c sh_telnetcln.c sh_telnetsrv.c
  group Shell Source/shell
    ../../../source/shell/: sh_cmdlist.c sh_exit.c sh_help.c sh_sh.c sh_util.c shell.c
    ../../../source/include/: sh_rtcs.h sh_enet.h
target release (ARM-ADS)
  device: MK60FN1M0xxx12 Freescale Semiconductor
  cpu: CPUTYPE("Cortex-M4.fp")
  output: shell.lib (library)
  AfterMake: ../../bat/shell_twrk60f120m.bat ../../../.. ../../../../lib/twrk60f120m.uv4/release/shell uv4
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG=1
  c misc: as above
  c include: as above
  asm misc: --cpreproc_opts '-DNDEBUG=1' --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk60f120m.uv4\mqx\intflash.scf
