<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>shell_svf522revb_m4</project><configuration>debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>shell_svf522revb_m4</project><configuration>release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\shell_svf522revb_m4.ewp</path></project></workspace>
