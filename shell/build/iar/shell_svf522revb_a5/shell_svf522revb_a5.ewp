# IAR project shell_svf522revb_a5.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../../source/include; ../../../source/include; ../../../source/include; ../../../../mqx/source/io/asrc; ../../../../mqx/source/io/cm; ../../../../mqx/source/io/cm/vybrid; ../../../../config/svf522revb_a5; ../../../../mqx/source/io/core_mutex; ../../../../mqx/source/io/dcu4; ../../../../mqx/source/io/dma; ../../../../mqx/source/io/enet/macnet; ../../../../mqx/source/io/enet/phy; ../../../../mqx/source/io/enet; ../../../../mqx/source/io/esai; ../../../../mqx/source/io/esai/esai_fifo; ../../../../mqx/source/io/esai/esai_vport; ../../../../mqx/source/io/esdhc; ../../../../mqx/source/io/fbdev; ../../../../mqx/source/io/flashx/freescale; ../../../../mqx/source/io/flashx; ../../../../mqx/source/io/flashx/amd; ../../../../mqx/source/io/flashx/fujitsu; ../../../../mqx/source/io/flashx/spansion; ../../../../mqx/source/io/flashx/atmel; ../../../../mqx/source/io/flashx/istrata; ../../../../mqx/source/io/flashx/sharp; ../../../../mqx/source/io/can/flexcan; ../../../../mqx/source/io/ftm; ../../../../mqx/source/io/ftm/quaddec; ../../../../mqx/source/io/hwtimer; ../../../../mqx/source/io/i2c; ../../../../mqx/source/io/i2c/polled; ../../../../mqx/source/io/i2c/int; ../../../../mqx/source/bsp/svf522revb_a5; ../../../../config/common; ../../../../mqx/source/include; ../../../../mqx/source/bsp/svf522revb_a5; ../../../../mqx/source/io/enet; ../../../../mqx/source/io/io_expander; ../../../../mqx/source/io/io_mem; ../../../../mqx/source/io/io_null; ../../../../mqx/source/io/pipe; ../../../../mqx/source/io/lpm/vybrid; ../../../../mqx/source/io/lpm; ../../../../mqx/source/io/lwadc; ../../../../mqx/source/io/lwgpio; ../../../../mqx/source/io/pcb/shmem; ../../../../mqx/source/io/pcb; ../../../../mqx/source/io/pcb/mqxa; ../../../../mqx/source/io/qspi; ../../../../mqx/source/io/sai; ../../../../mqx/source/io/sai/dma; ../../../../mqx/source/io/sdcard/sdcard_esdhc; ../../../../mqx/source/io/sdcard; ../../../../mqx/source/io/serial; ../../../../mqx/source/io/spi; ../../../../mqx/source/io/tfs; ../../../../mqx/source/io/usb; ../../../../mqx/source/psp/cortex_a/compiler/iar; ../../../../mqx/source/psp/cortex_a/cpu; ../../../../mqx/source/psp/cortex_a; ../../../../config/svf522revb_a5; ../../../../config/common; ../../../../mqx/source/include; ../../../../mqx/source/tad; ../../../../mfs/source/include; ../../../../rtcs/source/include; ../../../../ssl
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: ../../../../mqx/source/psp/cortex_a/compiler/iar; ../../../../mqx/source/psp/cortex_a; ../../../../mqx/source/psp/cortex_a/core/A5; ../../../../config/svf522revb_a5; ../../../../mqx/source/include; ../../../../config/common
  postbuild: "../../bat/shell_svf522revb_a5.bat" "../../../.." "../../../../lib/svf522revb_a5.iar/debug/shell" iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG=1
  postbuild: "../../bat/shell_svf522revb_a5.bat" "../../../.." "../../../../lib/svf522revb_a5.iar/release/shell" iar
  ILINK.IlinkOutputFile: libgeneric.out
  group Shell Source/mfs
    ../../../source/mfs/: sh_cache.c sh_cd.c sh_compare.c sh_copy.c sh_create.c sh_del.c sh_df.c sh_di.c sh_dir.c sh_dirent.c sh_disect.c sh_flush.c sh_format.c sh_mkdir.c sh_pwd.c sh_read.c sh_readtest.c sh_rename.c sh_rmdir.c sh_type.c sh_write.c sh_writetest.c
    ../../../source/include/: sh_mfs.h
  group Shell Source/mqx
    ../../../source/mqx/: sh_abort.c sh_kill.c sh_pause.c sh_tad.c
    ../../../source/include/: sh_prv.h shell.h
  group Shell Source/rtcs
    ../../../source/rtcs/: sh_arpdisp.c sh_clock.c sh_echo.c sh_echosrv.c sh_enet.c sh_ftpc.c sh_ftpsrv.c sh_gate.c sh_getroute.c sh_ghbn.c sh_getname.c sh_ipconfig.c sh_iwconfig.c sh_llmnrsrv.c sh_nat.c sh_nstat.c sh_ping.c sh_ppp.c sh_rtcs.c sh_sendto.c sh_smtp.c sh_snmpd.c sh_tftpcln.c sh_tftpsrv.c sh_telnetcln.c sh_telnetsrv.c
  group Shell Source/shell
    ../../../source/shell/: sh_cmdlist.c sh_exit.c sh_help.c sh_sh.c sh_util.c shell.c
    ../../../source/include/: sh_rtcs.h sh_enet.h
