<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>shell_frdmk22f120m</project><configuration>debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>shell_frdmk22f120m</project><configuration>release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\shell_frdmk22f120m.ewp</path></project></workspace>
