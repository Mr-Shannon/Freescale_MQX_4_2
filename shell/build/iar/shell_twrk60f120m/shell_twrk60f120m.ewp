# IAR project shell_twrk60f120m.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../../source/include; ../../../source/include; ../../../source/include; ../../../../mqx/source/io/adc/kadc; ../../../../mqx/source/io/adc; ../../../../mqx/source/io/cm; ../../../../config/twrk60f120m; ../../../../mqx/source/io/dma; ../../../../mqx/source/io/enet/macnet; ../../../../mqx/source/io/enet/phy; ../../../../mqx/source/io/enet; ../../../../mqx/source/io/esdhc; ../../../../mqx/source/io/flashx/freescale; ../../../../mqx/source/io/flashx; ../../../../mqx/source/io/flashx/amd; ../../../../mqx/source/io/flashx/fujitsu; ../../../../mqx/source/io/flashx/spansion; ../../../../mqx/source/io/flashx/atmel; ../../../../mqx/source/io/flashx/istrata; ../../../../mqx/source/io/flashx/sharp; ../../../../mqx/source/io/can/flexcan; ../../../../mqx/source/io/gpio/kgpio; ../../../../mqx/source/io/gpio; ../../../../mqx/source/io/hwtimer; ../../../../mqx/source/io/i2c; ../../../../mqx/source/io/i2c/polled; ../../../../mqx/source/io/i2c/int; ../../../../mqx/source/bsp/twrk60f120m; ../../../../config/common; ../../../../mqx/source/include; ../../../../mqx/source/bsp/twrk60f120m; ../../../../mqx/source/io/enet; ../../../../mqx/source/io/debug; ../../../../mqx/source/io/io_mem; ../../../../mqx/source/io/io_null; ../../../../mqx/source/io/pipe; ../../../../mqx/source/io/lpm; ../../../../mqx/source/io/lwadc; ../../../../mqx/source/io/lwgpio; ../../../../mqx/source/io/nandflash/nfc; ../../../../mqx/source/io/nandflash; ../../../../mqx/source/io/pcb; ../../../../mqx/source/io/pcb/mqxa; ../../../../mqx/source/io/pccard; ../../../../mqx/source/io/pcflash; ../../../../mqx/source/io/rtc; ../../../../mqx/source/io/sai; ../../../../mqx/source/io/sai/dma; ../../../../mqx/source/io/sdcard/sdcard_esdhc; ../../../../mqx/source/io/sdcard/sdcard_spi; ../../../../mqx/source/io/sdcard; ../../../../mqx/source/io/serial; ../../../../mqx/source/io/spi; ../../../../mqx/source/io/tchres; ../../../../mqx/source/io/tfs; ../../../../mqx/source/io/timer; ../../../../mqx/source/io/usb; ../../../../mqx/source/io/usb_dcd; ../../../../mqx/source/io/usb_dcd/polled; ../../../../mqx/source/io/usb_dcd/int; ../../../../mqx/source/psp/cortex_m/compiler/iar; ../../../../mqx/source/psp/cortex_m/cpu; ../../../../mqx/source/psp/cortex_m; ../../../../config/twrk60f120m; ../../../../config/common; ../../../../mqx/source/include; ../../../../mqx/source/tad; ../../../../mfs/source/include; ../../../../rtcs/source/include; ../../../../ssl
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: ../../../../mqx/source/io/debug; ../../../../mqx/source/psp/cortex_m/compiler/iar; ../../../../mqx/source/psp/cortex_m; ../../../../mqx/source/psp/cortex_m/core/M4; ../../../../config/twrk60f120m; ../../../../mqx/source/include; ../../../../config/common
  postbuild: "../../bat/shell_twrk60f120m.bat" "../../../.." "../../../../lib/twrk60f120m.iar/debug/shell" iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG=1
  postbuild: "../../bat/shell_twrk60f120m.bat" "../../../.." "../../../../lib/twrk60f120m.iar/release/shell" iar
  ILINK.IlinkOutputFile: libgeneric.out
  group Shell Source/mfs
    ../../../source/mfs/: sh_cache.c sh_cd.c sh_compare.c sh_copy.c sh_create.c sh_del.c sh_df.c sh_di.c sh_dir.c sh_dirent.c sh_disect.c sh_flush.c sh_format.c sh_mkdir.c sh_pwd.c sh_read.c sh_readtest.c sh_rename.c sh_rmdir.c sh_type.c sh_write.c sh_writetest.c
    ../../../source/include/: sh_mfs.h
  group Shell Source/mqx
    ../../../source/mqx/: sh_abort.c sh_kill.c sh_pause.c sh_tad.c
    ../../../source/include/: sh_prv.h shell.h
  group Shell Source/rtcs
    ../../../source/rtcs/: sh_arpdisp.c sh_clock.c sh_echo.c sh_echosrv.c sh_enet.c sh_ftpc.c sh_ftpsrv.c sh_gate.c sh_getroute.c sh_ghbn.c sh_getname.c sh_ipconfig.c sh_iwconfig.c sh_llmnrsrv.c sh_nat.c sh_nstat.c sh_ping.c sh_ppp.c sh_rtcs.c sh_sendto.c sh_smtp.c sh_snmpd.c sh_tftpcln.c sh_tftpsrv.c sh_telnetcln.c sh_telnetsrv.c
  group Shell Source/shell
    ../../../source/shell/: sh_cmdlist.c sh_exit.c sh_help.c sh_sh.c sh_util.c shell.c
    ../../../source/include/: sh_rtcs.h sh_enet.h
